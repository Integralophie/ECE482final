** Generated for: hspiceD
** Generated on: Dec  4 19:23:19 2023
** Design library name: ECE482final_cadence
** Design cell name: serializer_verticle_assem
** Design view name: av_extracted

.TEMP 25.0
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2

** Library name: ECE482final_cadence
** Cell name: serializer_verticle_assem
** View name: av_extracted
c1 vdd vss 4.16531e-18
c2 clk100m vss 60.0944e-18
c3 clk100m_b vss 43.4431e-18
c4 clk1pt6g vss 84.7539e-18
c5 clk1pt6g_b vss 71.4369e-18
c6 q0 vss 24.7817e-18
c7 q1 vss 15.9848e-18
c8 q10 vss 16.0309e-18
c9 q11 vss 16.0309e-18
c10 q12 vss 16.0309e-18
c11 q13 vss 16.0309e-18
c12 q14 vss 16.0309e-18
c13 q15 vss 15.8965e-18
c14 q2 vss 16.0309e-18
c15 q3 vss 16.0309e-18
c16 q4 vss 16.0309e-18
c17 q5 vss 16.0309e-18
c18 q6 vss 16.0309e-18
c19 q7 vss 16.0309e-18
c20 q8 vss 16.0309e-18
c21 q9 vss 16.0309e-18
c22 out vss 37.4904e-18
c23 i161__net5 vss 98.539e-18
c24 i161__net4 vss 90.5804e-18
c25 i161__x vss 42.7935e-18
c26 i161__net3 vss 103.474e-18
c27 i161__net2 vss 101.53e-18
c28 net8 vss 76.888e-18
c29 i144__net5 vss 99.3563e-18
c30 i144__net4 vss 91.7239e-18
c31 i144__x vss 41.9475e-18
c32 net7 vss 84.2506e-18
c33 i144__net3 vss 103.324e-18
c34 i144__net2 vss 100.743e-18
c35 net4 vss 76.5913e-18
c36 i143__net5 vss 99.3563e-18
c37 i143__net4 vss 91.7239e-18
c38 i143__x vss 41.9475e-18
c39 net13 vss 84.0653e-18
c40 i143__net3 vss 103.324e-18
c41 i143__net2 vss 100.743e-18
c42 net3 vss 76.5913e-18
c43 i142__net5 vss 99.3563e-18
c44 i142__net4 vss 91.7239e-18
c45 i142__x vss 41.9475e-18
c46 net18 vss 84.0653e-18
c47 i142__net3 vss 103.324e-18
c48 i142__net2 vss 100.743e-18
c49 net2 vss 76.5913e-18
c50 i141__net5 vss 99.3563e-18
c51 i141__net4 vss 91.7239e-18
c52 i141__x vss 41.9475e-18
c53 net34 vss 84.0653e-18
c54 i141__net3 vss 103.324e-18
c55 i141__net2 vss 100.743e-18
c56 net1 vss 76.5913e-18
c57 i140__net5 vss 99.3563e-18
c58 i140__net4 vss 91.7239e-18
c59 i140__x vss 41.9475e-18
c60 net6 vss 84.0653e-18
c61 i140__net3 vss 103.324e-18
c62 i140__net2 vss 100.743e-18
c63 net5 vss 76.5913e-18
c64 i139__net5 vss 99.3563e-18
c65 i139__net4 vss 91.7239e-18
c66 i139__x vss 41.9475e-18
c67 net12 vss 84.0653e-18
c68 i139__net3 vss 103.324e-18
c69 i139__net2 vss 100.743e-18
c70 net11 vss 76.5913e-18
c71 i138__net5 vss 99.3563e-18
c72 i138__net4 vss 91.7239e-18
c73 i138__x vss 41.9475e-18
c74 net25 vss 84.0653e-18
c75 i138__net3 vss 103.324e-18
c76 i138__net2 vss 100.743e-18
c77 net31 vss 76.5913e-18
c78 i137__net5 vss 99.3563e-18
c79 i137__net4 vss 91.7239e-18
c80 i137__x vss 41.9475e-18
c81 net23 vss 84.0653e-18
c82 i137__net3 vss 103.324e-18
c83 i137__net2 vss 100.743e-18
c84 net15 vss 76.5913e-18
c85 i136__net5 vss 99.3563e-18
c86 i136__net4 vss 91.7239e-18
c87 i136__x vss 41.9475e-18
c88 net14 vss 84.0653e-18
c89 i136__net3 vss 103.324e-18
c90 i136__net2 vss 100.743e-18
c91 net22 vss 76.5913e-18
c92 i135__net5 vss 99.3563e-18
c93 i135__net4 vss 91.7239e-18
c94 i135__x vss 41.9475e-18
c95 net21 vss 84.0653e-18
c96 i135__net3 vss 103.324e-18
c97 i135__net2 vss 100.743e-18
c98 net30 vss 76.5913e-18
c99 i134__net5 vss 99.3563e-18
c100 i134__net4 vss 91.7239e-18
c101 i134__x vss 41.9475e-18
c102 net29 vss 84.0653e-18
c103 i134__net3 vss 103.324e-18
c104 i134__net2 vss 100.743e-18
c105 net17 vss 76.5913e-18
c106 i133__net5 vss 99.3563e-18
c107 i133__net4 vss 91.7239e-18
c108 i133__x vss 41.9475e-18
c109 net16 vss 84.0653e-18
c110 i133__net3 vss 103.324e-18
c111 i133__net2 vss 100.743e-18
c112 net10 vss 76.5913e-18
c113 i132__net5 vss 99.3563e-18
c114 i132__net4 vss 91.7239e-18
c115 i132__x vss 41.9475e-18
c116 net9 vss 84.0653e-18
c117 i132__net3 vss 103.324e-18
c118 i132__net2 vss 100.743e-18
c119 net20 vss 76.5913e-18
c120 i131__net5 vss 99.3563e-18
c121 i131__net4 vss 91.7239e-18
c122 i131__x vss 41.9475e-18
c123 net19 vss 84.0653e-18
c124 i131__net3 vss 103.324e-18
c125 i131__net2 vss 100.743e-18
c126 net27 vss 77.0033e-18
c127 i130__net5 vss 99.3645e-18
c128 i130__net4 vss 91.7239e-18
c129 i130__x vss 41.9047e-18
c130 net26 vss 84.0389e-18
c131 i130__net3 vss 98.6181e-18
c132 i130__net2 vss 100.488e-18
c133 n127__clk1pt6g_b vss 30.7585e-18
c134 n144__clk1pt6g vss 32.2579e-18
c135 n118__clk1pt6g_b vss 30.3092e-18
c136 n66__clk100m vss 31.4027e-18
c137 n45__clk100m_b vss 57.6288e-18
c138 n133__clk1pt6g vss 31.7196e-18
c139 n109__clk1pt6g_b vss 30.3036e-18
c140 n61__clk100m vss 32.3629e-18
c141 n42__clk100m_b vss 57.7291e-18
c142 n122__clk1pt6g vss 31.7196e-18
c143 n100__clk1pt6g_b vss 30.3036e-18
c144 n56__clk100m vss 32.3629e-18
c145 n39__clk100m_b vss 57.7291e-18
c146 n111__clk1pt6g vss 31.7196e-18
c147 n91__clk1pt6g_b vss 30.3036e-18
c148 n51__clk100m vss 32.3629e-18
c149 n36__clk100m_b vss 57.7291e-18
c150 n100__clk1pt6g vss 31.7196e-18
c151 n82__clk1pt6g_b vss 30.3036e-18
c152 n46__clk100m vss 32.3629e-18
c153 n33__clk100m_b vss 57.7291e-18
c154 n89__clk1pt6g vss 31.7196e-18
c155 n73__clk1pt6g_b vss 30.3036e-18
c156 n41__clk100m vss 32.3629e-18
c157 n30__clk100m_b vss 57.7291e-18
c158 n78__clk1pt6g vss 31.7196e-18
c159 n64__clk1pt6g_b vss 30.3036e-18
c160 n36__clk100m vss 32.3629e-18
c161 n27__clk100m_b vss 57.7291e-18
c162 n67__clk1pt6g vss 31.7196e-18
c163 n55__clk1pt6g_b vss 30.3036e-18
c164 n31__clk100m vss 32.3629e-18
c165 n24__clk100m_b vss 57.7291e-18
c166 n56__clk1pt6g vss 31.7196e-18
c167 n46__clk1pt6g_b vss 30.3036e-18
c168 n26__clk100m vss 32.3629e-18
c169 n21__clk100m_b vss 57.7291e-18
c170 n45__clk1pt6g vss 31.7196e-18
c171 n37__clk1pt6g_b vss 30.3036e-18
c172 n21__clk100m vss 32.3629e-18
c173 n18__clk100m_b vss 57.7291e-18
c174 n34__clk1pt6g vss 31.7196e-18
c175 n28__clk1pt6g_b vss 30.3036e-18
c176 n16__clk100m vss 32.3629e-18
c177 n15__clk100m_b vss 57.7291e-18
c178 n23__clk1pt6g vss 31.7196e-18
c179 n19__clk1pt6g_b vss 30.3036e-18
c180 n11__clk100m vss 32.3629e-18
c181 n12__clk100m_b vss 57.7291e-18
c182 n16__clk1pt6g vss 31.7196e-18
c183 n14__clk1pt6g_b vss 30.3036e-18
c184 n8__clk100m vss 32.3629e-18
c185 n9__clk100m_b vss 57.7291e-18
c186 n11__clk1pt6g vss 31.7196e-18
c187 n9__clk1pt6g_b vss 30.3036e-18
c188 n5__clk100m vss 32.3629e-18
c189 n6__clk100m_b vss 57.7291e-18
c190 n6__clk1pt6g vss 31.7196e-18
c191 n4__clk1pt6g_b vss 30.3158e-18
c192 n2__clk100m vss 32.6935e-18
c193 n3__clk100m_b vss 52.5197e-18
c194 n1__clk1pt6g vss 30.2247e-18
c195 n1__q0 vss 41.2214e-18
c196 n151__clk1pt6g vss 16.6348e-18
c197 n4__i161__x vss 31.504e-18
c198 n124__clk1pt6g_b vss 17.4862e-18
c199 n3__net8 vss 53.4286e-18
c200 n140__clk1pt6g vss 17.2331e-18
c201 n4__i144__x vss 31.5507e-18
c202 n65__clk100m vss 54.7077e-18
c203 n43__clk100m_b vss 34.1295e-18
c204 n115__clk1pt6g_b vss 17.4767e-18
c205 n3__net4 vss 53.5331e-18
c206 n129__clk1pt6g vss 17.229e-18
c207 n4__i143__x vss 31.5507e-18
c208 n60__clk100m vss 58.0952e-18
c209 n40__clk100m_b vss 34.1232e-18
c210 n106__clk1pt6g_b vss 17.4767e-18
c211 n3__net3 vss 53.5331e-18
c212 n118__clk1pt6g vss 17.229e-18
c213 n4__i142__x vss 31.5507e-18
c214 n55__clk100m vss 58.0952e-18
c215 n37__clk100m_b vss 34.1232e-18
c216 n97__clk1pt6g_b vss 17.4767e-18
c217 n3__net2 vss 53.5331e-18
c218 n107__clk1pt6g vss 17.229e-18
c219 n4__i141__x vss 31.5507e-18
c220 n50__clk100m vss 58.0952e-18
c221 n34__clk100m_b vss 34.1232e-18
c222 n88__clk1pt6g_b vss 17.4767e-18
c223 n3__net1 vss 53.5331e-18
c224 n96__clk1pt6g vss 17.229e-18
c225 n4__i140__x vss 31.5507e-18
c226 n45__clk100m vss 58.0952e-18
c227 n31__clk100m_b vss 34.1232e-18
c228 n79__clk1pt6g_b vss 17.4767e-18
c229 n3__net5 vss 53.5331e-18
c230 n85__clk1pt6g vss 17.229e-18
c231 n4__i139__x vss 31.5507e-18
c232 n40__clk100m vss 58.0952e-18
c233 n28__clk100m_b vss 34.1232e-18
c234 n70__clk1pt6g_b vss 17.4767e-18
c235 n3__net11 vss 53.5331e-18
c236 n74__clk1pt6g vss 17.229e-18
c237 n4__i138__x vss 31.5507e-18
c238 n35__clk100m vss 58.0952e-18
c239 n25__clk100m_b vss 34.1232e-18
c240 n61__clk1pt6g_b vss 17.4767e-18
c241 n3__net31 vss 53.5331e-18
c242 n63__clk1pt6g vss 17.229e-18
c243 n4__i137__x vss 31.5507e-18
c244 n30__clk100m vss 58.0952e-18
c245 n22__clk100m_b vss 34.1232e-18
c246 n52__clk1pt6g_b vss 17.4767e-18
c247 n3__net15 vss 53.5331e-18
c248 n52__clk1pt6g vss 17.229e-18
c249 n4__i136__x vss 31.5507e-18
c250 n25__clk100m vss 58.0952e-18
c251 n19__clk100m_b vss 34.1232e-18
c252 n43__clk1pt6g_b vss 17.4767e-18
c253 n3__net22 vss 53.5331e-18
c254 n41__clk1pt6g vss 17.229e-18
c255 n4__i135__x vss 31.5507e-18
c256 n20__clk100m vss 58.0952e-18
c257 n16__clk100m_b vss 34.1232e-18
c258 n34__clk1pt6g_b vss 17.4767e-18
c259 n3__net30 vss 53.5331e-18
c260 n30__clk1pt6g vss 17.229e-18
c261 n4__i134__x vss 31.5507e-18
c262 n15__clk100m vss 58.0952e-18
c263 n13__clk100m_b vss 34.1232e-18
c264 n25__clk1pt6g_b vss 17.4767e-18
c265 n3__net17 vss 53.5331e-18
c266 n19__clk1pt6g vss 17.229e-18
c267 n4__i133__x vss 31.5507e-18
c268 n10__clk100m vss 58.0952e-18
c269 n10__clk100m_b vss 34.1232e-18
c270 n17__clk1pt6g_b vss 17.4767e-18
c271 n3__net10 vss 53.5331e-18
c272 n14__clk1pt6g vss 17.229e-18
c273 n4__i132__x vss 31.5507e-18
c274 n7__clk100m vss 58.0952e-18
c275 n7__clk100m_b vss 34.1232e-18
c276 n12__clk1pt6g_b vss 17.4767e-18
c277 n3__net20 vss 53.5331e-18
c278 n9__clk1pt6g vss 17.229e-18
c279 n4__i131__x vss 31.5507e-18
c280 n4__clk100m vss 58.0952e-18
c281 n4__clk100m_b vss 34.1232e-18
c282 n7__clk1pt6g_b vss 17.4767e-18
c283 n3__net27 vss 53.5366e-18
c284 n4__clk1pt6g vss 17.2303e-18
c285 n4__i130__x vss 31.5083e-18
c286 n1__clk100m vss 57.8906e-18
c287 n1__clk100m_b vss 33.4552e-18
c288 n2__clk1pt6g_b vss 17.4796e-18
c289 n3__q0 vss 33.8163e-18
c290 n128__clk1pt6g_b vss 32.098e-18
c291 n150__clk1pt6g vss 29.7823e-18
c292 n152__clk1pt6g vss 23.0055e-18
c293 n3__i161__x vss 37.4267e-18
c294 n145__clk1pt6g vss 96.8479e-18
c295 n123__clk1pt6g_b vss 73.605e-18
c296 n125__clk1pt6g_b vss 23.5199e-18
c297 n2__net8 vss 103.009e-18
c298 n119__clk1pt6g_b vss 32.2058e-18
c299 n139__clk1pt6g vss 29.6206e-18
c300 n141__clk1pt6g vss 25.5924e-18
c301 n67__clk100m vss 23.2002e-18
c302 n3__i144__x vss 38.6706e-18
c303 n44__clk100m_b vss 307.096e-18
c304 n134__clk1pt6g vss 31.5314e-18
c305 n114__clk1pt6g_b vss 73.6157e-18
c306 n116__clk1pt6g_b vss 23.7322e-18
c307 n2__net4 vss 104.093e-18
c308 n110__clk1pt6g_b vss 32.1898e-18
c309 n128__clk1pt6g vss 29.6206e-18
c310 n130__clk1pt6g vss 25.6719e-18
c311 n62__clk100m vss 23.1889e-18
c312 n3__i143__x vss 38.6706e-18
c313 n41__clk100m_b vss 277.074e-18
c314 n123__clk1pt6g vss 31.5314e-18
c315 n105__clk1pt6g_b vss 73.6157e-18
c316 n107__clk1pt6g_b vss 23.7322e-18
c317 n2__net3 vss 103.971e-18
c318 n101__clk1pt6g_b vss 32.1898e-18
c319 n117__clk1pt6g vss 29.6206e-18
c320 n119__clk1pt6g vss 25.6719e-18
c321 n57__clk100m vss 23.1889e-18
c322 n3__i142__x vss 38.6706e-18
c323 n38__clk100m_b vss 277.074e-18
c324 n112__clk1pt6g vss 31.5314e-18
c325 n96__clk1pt6g_b vss 73.6157e-18
c326 n98__clk1pt6g_b vss 23.7322e-18
c327 n2__net2 vss 103.971e-18
c328 n92__clk1pt6g_b vss 32.1898e-18
c329 n106__clk1pt6g vss 29.6206e-18
c330 n108__clk1pt6g vss 25.6719e-18
c331 n52__clk100m vss 137.909e-18
c332 n3__i141__x vss 38.6706e-18
c333 n35__clk100m_b vss 277.074e-18
c334 n101__clk1pt6g vss 31.5314e-18
c335 n87__clk1pt6g_b vss 73.6157e-18
c336 n89__clk1pt6g_b vss 23.7322e-18
c337 n2__net1 vss 103.971e-18
c338 n83__clk1pt6g_b vss 32.1898e-18
c339 n95__clk1pt6g vss 29.6206e-18
c340 n97__clk1pt6g vss 25.6719e-18
c341 n47__clk100m vss 23.1889e-18
c342 n3__i140__x vss 38.6706e-18
c343 n32__clk100m_b vss 277.074e-18
c344 n90__clk1pt6g vss 31.5314e-18
c345 n78__clk1pt6g_b vss 73.6157e-18
c346 n80__clk1pt6g_b vss 23.7322e-18
c347 n2__net5 vss 103.971e-18
c348 n74__clk1pt6g_b vss 32.1898e-18
c349 n84__clk1pt6g vss 29.6206e-18
c350 n86__clk1pt6g vss 25.6719e-18
c351 n42__clk100m vss 137.909e-18
c352 n3__i139__x vss 38.6706e-18
c353 n29__clk100m_b vss 277.074e-18
c354 n79__clk1pt6g vss 31.5314e-18
c355 n69__clk1pt6g_b vss 73.6157e-18
c356 n71__clk1pt6g_b vss 23.7322e-18
c357 n2__net11 vss 103.971e-18
c358 n65__clk1pt6g_b vss 32.1898e-18
c359 n73__clk1pt6g vss 29.6206e-18
c360 n75__clk1pt6g vss 25.6719e-18
c361 n37__clk100m vss 23.1889e-18
c362 n3__i138__x vss 38.6706e-18
c363 n26__clk100m_b vss 277.074e-18
c364 n68__clk1pt6g vss 31.5314e-18
c365 n60__clk1pt6g_b vss 73.6157e-18
c366 n62__clk1pt6g_b vss 23.7322e-18
c367 n2__net31 vss 103.971e-18
c368 n56__clk1pt6g_b vss 32.1898e-18
c369 n62__clk1pt6g vss 29.6206e-18
c370 n64__clk1pt6g vss 25.6719e-18
c371 n32__clk100m vss 23.1889e-18
c372 n3__i137__x vss 38.6706e-18
c373 n23__clk100m_b vss 277.074e-18
c374 n57__clk1pt6g vss 31.5314e-18
c375 n51__clk1pt6g_b vss 73.6157e-18
c376 n53__clk1pt6g_b vss 23.7322e-18
c377 n2__net15 vss 103.971e-18
c378 n47__clk1pt6g_b vss 32.1898e-18
c379 n51__clk1pt6g vss 29.6206e-18
c380 n53__clk1pt6g vss 25.6719e-18
c381 n27__clk100m vss 23.1889e-18
c382 n3__i136__x vss 38.6706e-18
c383 n20__clk100m_b vss 277.074e-18
c384 n46__clk1pt6g vss 31.5314e-18
c385 n42__clk1pt6g_b vss 73.6157e-18
c386 n44__clk1pt6g_b vss 23.7322e-18
c387 n2__net22 vss 103.971e-18
c388 n38__clk1pt6g_b vss 32.1898e-18
c389 n40__clk1pt6g vss 29.6206e-18
c390 n42__clk1pt6g vss 25.6719e-18
c391 n22__clk100m vss 23.1889e-18
c392 n3__i135__x vss 38.6706e-18
c393 n17__clk100m_b vss 277.074e-18
c394 n35__clk1pt6g vss 31.5314e-18
c395 n33__clk1pt6g_b vss 73.6157e-18
c396 n35__clk1pt6g_b vss 23.7322e-18
c397 n2__net30 vss 103.971e-18
c398 n29__clk1pt6g_b vss 32.1898e-18
c399 n29__clk1pt6g vss 29.6206e-18
c400 n31__clk1pt6g vss 25.6719e-18
c401 n17__clk100m vss 23.1889e-18
c402 n3__i134__x vss 38.6706e-18
c403 n14__clk100m_b vss 277.074e-18
c404 n24__clk1pt6g vss 31.5314e-18
c405 n24__clk1pt6g_b vss 73.6157e-18
c406 n26__clk1pt6g_b vss 23.7322e-18
c407 n2__net17 vss 103.971e-18
c408 n20__clk1pt6g_b vss 32.1898e-18
c409 n18__clk1pt6g vss 29.6206e-18
c410 n20__clk1pt6g vss 25.6719e-18
c411 n12__clk100m vss 23.1889e-18
c412 n3__i133__x vss 38.6706e-18
c413 n11__clk100m_b vss 277.074e-18
c414 n17__clk1pt6g vss 31.5314e-18
c415 n16__clk1pt6g_b vss 73.6157e-18
c416 n18__clk1pt6g_b vss 23.7322e-18
c417 n2__net10 vss 103.971e-18
c418 n15__clk1pt6g_b vss 32.1898e-18
c419 n13__clk1pt6g vss 29.6206e-18
c420 n15__clk1pt6g vss 25.6719e-18
c421 n9__clk100m vss 23.1889e-18
c422 n3__i132__x vss 38.6706e-18
c423 n8__clk100m_b vss 277.074e-18
c424 n12__clk1pt6g vss 31.5314e-18
c425 n11__clk1pt6g_b vss 73.6157e-18
c426 n13__clk1pt6g_b vss 23.7322e-18
c427 n2__net20 vss 103.971e-18
c428 n10__clk1pt6g_b vss 32.1898e-18
c429 n8__clk1pt6g vss 29.6206e-18
c430 n10__clk1pt6g vss 25.6719e-18
c431 n6__clk100m vss 23.1889e-18
c432 n3__i131__x vss 38.6706e-18
c433 n5__clk100m_b vss 277.074e-18
c434 n7__clk1pt6g vss 31.5314e-18
c435 n6__clk1pt6g_b vss 73.6157e-18
c436 n8__clk1pt6g_b vss 23.7322e-18
c437 n2__net27 vss 103.971e-18
c438 n5__clk1pt6g_b vss 32.2008e-18
c439 n3__clk1pt6g vss 29.6227e-18
c440 n5__clk1pt6g vss 25.7097e-18
c441 n3__clk100m vss 21.7306e-18
c442 n3__i130__x vss 39.2334e-18
c443 n2__clk100m_b vss 173.776e-18
c444 n2__clk1pt6g vss 31.2266e-18
c445 n1__clk1pt6g_b vss 73.8752e-18
c446 n3__clk1pt6g_b vss 21.1196e-18
c447 n2__q0 vss 92.2079e-18
c448 n176__clk1pt6g vss 32.2612e-18
c449 n175__clk1pt6g vss 65.4748e-18
c450 n8__q15 vss 92.1575e-18
c451 n75__clk100m vss 95.7432e-18
c452 n7__q15 vss 37.8277e-18
c453 n174__clk1pt6g vss 64.9664e-18
c454 n8__q14 vss 94.4518e-18
c455 n74__clk100m vss 82.5019e-18
c456 n7__q14 vss 37.8032e-18
c457 n173__clk1pt6g vss 64.9664e-18
c458 n8__q13 vss 94.4329e-18
c459 n73__clk100m vss 82.5019e-18
c460 n7__q13 vss 37.8032e-18
c461 n147__clk1pt6g vss 64.9664e-18
c462 n8__q12 vss 94.4329e-18
c463 n69__clk100m vss 82.5019e-18
c464 n7__q12 vss 37.8032e-18
c465 n138__clk1pt6g vss 64.9664e-18
c466 n5__q11 vss 94.4329e-18
c467 n64__clk100m vss 82.5019e-18
c468 n4__q11 vss 37.8032e-18
c469 n127__clk1pt6g vss 64.9664e-18
c470 n5__q10 vss 94.4329e-18
c471 n59__clk100m vss 82.5019e-18
c472 n4__q10 vss 37.8032e-18
c473 n116__clk1pt6g vss 64.9664e-18
c474 n5__q9 vss 94.4329e-18
c475 n54__clk100m vss 82.5019e-18
c476 n4__q9 vss 37.8032e-18
c477 n105__clk1pt6g vss 64.9664e-18
c478 n5__q8 vss 94.4329e-18
c479 n49__clk100m vss 82.5019e-18
c480 n4__q8 vss 37.8032e-18
c481 n94__clk1pt6g vss 64.9664e-18
c482 n5__q7 vss 94.4329e-18
c483 n44__clk100m vss 82.5019e-18
c484 n4__q7 vss 37.8032e-18
c485 n83__clk1pt6g vss 64.9664e-18
c486 n5__q6 vss 94.4329e-18
c487 n39__clk100m vss 82.5019e-18
c488 n4__q6 vss 37.8032e-18
c489 n72__clk1pt6g vss 64.9664e-18
c490 n5__q5 vss 94.4329e-18
c491 n34__clk100m vss 82.5019e-18
c492 n4__q5 vss 37.8032e-18
c493 n61__clk1pt6g vss 64.9664e-18
c494 n5__q4 vss 94.4329e-18
c495 n29__clk100m vss 82.5019e-18
c496 n4__q4 vss 37.8032e-18
c497 n50__clk1pt6g vss 64.9664e-18
c498 n5__q3 vss 94.4329e-18
c499 n24__clk100m vss 82.5019e-18
c500 n4__q3 vss 37.8032e-18
c501 n39__clk1pt6g vss 64.9664e-18
c502 n5__q2 vss 94.4329e-18
c503 n19__clk100m vss 82.5019e-18
c504 n4__q2 vss 37.8032e-18
c505 n28__clk1pt6g vss 102.264e-18
c506 n5__q1 vss 94.9488e-18
c507 n14__clk100m vss 106.99e-18
c508 n4__q1 vss 37.035e-18
c509 n144__clk1pt6g_b vss 133.44e-18
c510 n170__clk1pt6g vss 165.167e-18
c511 n172__clk1pt6g vss 76.5764e-18
c512 n143__clk1pt6g_b vss 114.495e-18
c513 n169__clk1pt6g vss 132.618e-18
c514 n142__clk1pt6g_b vss 151.979e-18
c515 n9__net7 vss 163.058e-18
c516 n140__clk1pt6g_b vss 146.753e-18
c517 n165__clk1pt6g vss 164.554e-18
c518 n166__clk1pt6g vss 132.736e-18
c519 n8__net7 vss 51.7724e-18
c520 n6__q15 vss 101.038e-18
c521 n72__clk100m vss 142.314e-18
c522 n3__net7 vss 74.9206e-18
c523 n3__q15 vss 117.267e-18
c524 n139__clk1pt6g_b vss 119.137e-18
c525 n163__clk1pt6g vss 196.311e-18
c526 n137__clk1pt6g_b vss 98.455e-18
c527 n9__net13 vss 161.254e-18
c528 n136__clk1pt6g_b vss 146.713e-18
c529 n160__clk1pt6g vss 164.602e-18
c530 n161__clk1pt6g vss 131.818e-18
c531 n8__net13 vss 52.5782e-18
c532 n6__q14 vss 98.7453e-18
c533 n71__clk100m vss 142.259e-18
c534 n3__net13 vss 74.8884e-18
c535 n3__q14 vss 117.267e-18
c536 n135__clk1pt6g_b vss 119.137e-18
c537 n158__clk1pt6g vss 196.311e-18
c538 n133__clk1pt6g_b vss 98.455e-18
c539 n9__net18 vss 161.254e-18
c540 n132__clk1pt6g_b vss 146.713e-18
c541 n155__clk1pt6g vss 164.602e-18
c542 n156__clk1pt6g vss 131.818e-18
c543 n8__net18 vss 52.5782e-18
c544 n6__q13 vss 98.7453e-18
c545 n70__clk100m vss 142.259e-18
c546 n3__net18 vss 74.8884e-18
c547 n3__q13 vss 117.267e-18
c548 n131__clk1pt6g_b vss 119.137e-18
c549 n153__clk1pt6g vss 196.311e-18
c550 n129__clk1pt6g_b vss 98.455e-18
c551 n9__net34 vss 161.254e-18
c552 n126__clk1pt6g_b vss 146.713e-18
c553 n148__clk1pt6g vss 164.602e-18
c554 n146__clk1pt6g vss 131.818e-18
c555 n8__net34 vss 52.5782e-18
c556 n6__q12 vss 98.7453e-18
c557 n68__clk100m vss 27.5394e-18
c558 n3__net34 vss 74.8884e-18
c559 n3__q12 vss 117.267e-18
c560 n122__clk1pt6g_b vss 119.137e-18
c561 n142__clk1pt6g vss 196.311e-18
c562 n120__clk1pt6g_b vss 98.455e-18
c563 n9__net6 vss 161.254e-18
c564 n117__clk1pt6g_b vss 146.713e-18
c565 n135__clk1pt6g vss 164.602e-18
c566 n136__clk1pt6g vss 131.818e-18
c567 n8__net6 vss 52.5782e-18
c568 n8__q11 vss 98.7453e-18
c569 n63__clk100m vss 142.259e-18
c570 n3__net6 vss 74.8884e-18
c571 n3__q11 vss 117.267e-18
c572 n113__clk1pt6g_b vss 119.137e-18
c573 n131__clk1pt6g vss 196.311e-18
c574 n111__clk1pt6g_b vss 98.455e-18
c575 n9__net12 vss 161.254e-18
c576 n108__clk1pt6g_b vss 146.713e-18
c577 n124__clk1pt6g vss 164.602e-18
c578 n125__clk1pt6g vss 131.818e-18
c579 n8__net12 vss 52.5782e-18
c580 n8__q10 vss 98.7453e-18
c581 n58__clk100m vss 27.5394e-18
c582 n3__net12 vss 74.8884e-18
c583 n3__q10 vss 117.267e-18
c584 n104__clk1pt6g_b vss 119.137e-18
c585 n120__clk1pt6g vss 196.311e-18
c586 n102__clk1pt6g_b vss 98.455e-18
c587 n9__net25 vss 161.254e-18
c588 n99__clk1pt6g_b vss 146.713e-18
c589 n113__clk1pt6g vss 164.602e-18
c590 n114__clk1pt6g vss 131.818e-18
c591 n8__net25 vss 52.5782e-18
c592 n8__q9 vss 98.7453e-18
c593 n53__clk100m vss 142.259e-18
c594 n3__net25 vss 74.8884e-18
c595 n3__q9 vss 117.267e-18
c596 n95__clk1pt6g_b vss 119.137e-18
c597 n109__clk1pt6g vss 196.311e-18
c598 n93__clk1pt6g_b vss 98.455e-18
c599 n9__net23 vss 161.254e-18
c600 n90__clk1pt6g_b vss 146.713e-18
c601 n102__clk1pt6g vss 164.602e-18
c602 n103__clk1pt6g vss 131.818e-18
c603 n8__net23 vss 52.5782e-18
c604 n8__q8 vss 98.7453e-18
c605 n48__clk100m vss 142.259e-18
c606 n3__net23 vss 74.8884e-18
c607 n3__q8 vss 117.267e-18
c608 n86__clk1pt6g_b vss 119.137e-18
c609 n98__clk1pt6g vss 196.311e-18
c610 n84__clk1pt6g_b vss 98.455e-18
c611 n9__net14 vss 161.254e-18
c612 n81__clk1pt6g_b vss 146.713e-18
c613 n91__clk1pt6g vss 164.602e-18
c614 n92__clk1pt6g vss 131.818e-18
c615 n8__net14 vss 52.5782e-18
c616 n8__q7 vss 98.7453e-18
c617 n43__clk100m vss 142.259e-18
c618 n3__net14 vss 74.8884e-18
c619 n3__q7 vss 117.267e-18
c620 n77__clk1pt6g_b vss 119.137e-18
c621 n87__clk1pt6g vss 196.311e-18
c622 n75__clk1pt6g_b vss 98.455e-18
c623 n9__net21 vss 161.254e-18
c624 n72__clk1pt6g_b vss 146.713e-18
c625 n80__clk1pt6g vss 164.602e-18
c626 n81__clk1pt6g vss 131.818e-18
c627 n8__net21 vss 52.5782e-18
c628 n8__q6 vss 98.7453e-18
c629 n38__clk100m vss 142.259e-18
c630 n3__net21 vss 74.8884e-18
c631 n3__q6 vss 117.267e-18
c632 n68__clk1pt6g_b vss 119.137e-18
c633 n76__clk1pt6g vss 196.311e-18
c634 n66__clk1pt6g_b vss 98.455e-18
c635 n9__net29 vss 161.254e-18
c636 n63__clk1pt6g_b vss 146.713e-18
c637 n69__clk1pt6g vss 164.602e-18
c638 n70__clk1pt6g vss 131.818e-18
c639 n8__net29 vss 52.5782e-18
c640 n8__q5 vss 98.7453e-18
c641 n33__clk100m vss 142.259e-18
c642 n3__net29 vss 74.8884e-18
c643 n3__q5 vss 117.267e-18
c644 n59__clk1pt6g_b vss 119.137e-18
c645 n65__clk1pt6g vss 196.311e-18
c646 n57__clk1pt6g_b vss 98.455e-18
c647 n9__net16 vss 161.254e-18
c648 n54__clk1pt6g_b vss 146.713e-18
c649 n58__clk1pt6g vss 164.602e-18
c650 n59__clk1pt6g vss 131.818e-18
c651 n8__net16 vss 52.5782e-18
c652 n8__q4 vss 98.7453e-18
c653 n28__clk100m vss 142.259e-18
c654 n3__net16 vss 74.8884e-18
c655 n3__q4 vss 117.267e-18
c656 n50__clk1pt6g_b vss 119.137e-18
c657 n54__clk1pt6g vss 196.311e-18
c658 n48__clk1pt6g_b vss 98.455e-18
c659 n9__net9 vss 161.254e-18
c660 n45__clk1pt6g_b vss 146.713e-18
c661 n47__clk1pt6g vss 164.602e-18
c662 n48__clk1pt6g vss 131.818e-18
c663 n8__net9 vss 52.5782e-18
c664 n8__q3 vss 98.7453e-18
c665 n23__clk100m vss 142.259e-18
c666 n3__net9 vss 74.8884e-18
c667 n3__q3 vss 117.267e-18
c668 n41__clk1pt6g_b vss 119.137e-18
c669 n43__clk1pt6g vss 196.311e-18
c670 n39__clk1pt6g_b vss 98.455e-18
c671 n9__net19 vss 161.254e-18
c672 n36__clk1pt6g_b vss 146.713e-18
c673 n36__clk1pt6g vss 164.602e-18
c674 n37__clk1pt6g vss 131.818e-18
c675 n8__net19 vss 52.5782e-18
c676 n8__q2 vss 98.7453e-18
c677 n18__clk100m vss 142.259e-18
c678 n3__net19 vss 74.8884e-18
c679 n3__q2 vss 117.267e-18
c680 n32__clk1pt6g_b vss 119.137e-18
c681 n32__clk1pt6g vss 196.349e-18
c682 n30__clk1pt6g_b vss 98.4619e-18
c683 n9__net26 vss 161.592e-18
c684 n27__clk1pt6g_b vss 146.842e-18
c685 n25__clk1pt6g vss 166.342e-18
c686 n26__clk1pt6g vss 123.569e-18
c687 n8__net26 vss 52.7645e-18
c688 n8__q1 vss 98.9568e-18
c689 n13__clk100m vss 140.053e-18
c690 n3__net26 vss 71.1176e-18
c691 n3__q1 vss 111.959e-18
c692 n23__clk1pt6g_b vss 119.62e-18
c693 n21__clk1pt6g vss 208.249e-18
c694 n21__clk1pt6g_b vss 99.2795e-18
c695 n51__vdd vss 7.34217e-15
c696 n1__out vss 81.9518e-18
c697 n49__vdd vss 51.1153e-18
c698 n7__i161__x vss 96.2361e-18
c699 n50__vdd vss 59.8707e-18
c700 n10__net7 vss 177.233e-21
c701 n2__out vss 77.3444e-18
c702 n6__i161__x vss 82.3169e-18
c703 n12__net7 vss 102.819e-18
c704 n52__vdd vss 50.6095e-18
c705 n5__net8 vss 80.806e-18
c706 n7__i144__x vss 97.6376e-18
c707 n53__vdd vss 59.9488e-18
c708 n10__net13 vss 177.233e-21
c709 n6__net8 vss 51.3803e-18
c710 n6__i144__x vss 83.2822e-18
c711 n12__net13 vss 102.818e-18
c712 n54__vdd vss 50.6095e-18
c713 n5__net4 vss 81.0259e-18
c714 n7__i143__x vss 97.6376e-18
c715 n55__vdd vss 59.9488e-18
c716 n10__net18 vss 177.233e-21
c717 n6__net4 vss 51.3429e-18
c718 n6__i143__x vss 83.2822e-18
c719 n12__net18 vss 102.818e-18
c720 n56__vdd vss 50.6095e-18
c721 n5__net3 vss 81.0259e-18
c722 n7__i142__x vss 97.6376e-18
c723 n57__vdd vss 59.9488e-18
c724 n10__net34 vss 177.233e-21
c725 n6__net3 vss 51.3429e-18
c726 n6__i142__x vss 83.2822e-18
c727 n12__net34 vss 102.818e-18
c728 n58__vdd vss 50.6095e-18
c729 n5__net2 vss 81.0259e-18
c730 n7__i141__x vss 97.6376e-18
c731 n59__vdd vss 59.9488e-18
c732 n11__net6 vss 177.233e-21
c733 n6__net2 vss 51.3429e-18
c734 n6__i141__x vss 83.2822e-18
c735 n13__net6 vss 102.818e-18
c736 n60__vdd vss 50.6095e-18
c737 n5__net1 vss 81.0259e-18
c738 n7__i140__x vss 97.6376e-18
c739 n61__vdd vss 59.9488e-18
c740 n11__net12 vss 177.233e-21
c741 n6__net1 vss 51.3429e-18
c742 n6__i140__x vss 83.2822e-18
c743 n13__net12 vss 102.818e-18
c744 n62__vdd vss 50.6095e-18
c745 n5__net5 vss 81.0259e-18
c746 n7__i139__x vss 97.6376e-18
c747 n63__vdd vss 59.9488e-18
c748 n11__net25 vss 177.233e-21
c749 n6__net5 vss 51.3429e-18
c750 n6__i139__x vss 83.2822e-18
c751 n13__net25 vss 102.818e-18
c752 n64__vdd vss 50.6095e-18
c753 n5__net11 vss 81.0259e-18
c754 n7__i138__x vss 97.6376e-18
c755 n65__vdd vss 59.9488e-18
c756 n11__net23 vss 177.233e-21
c757 n6__net11 vss 51.3429e-18
c758 n6__i138__x vss 83.2822e-18
c759 n13__net23 vss 102.818e-18
c760 n66__vdd vss 50.6095e-18
c761 n5__net31 vss 81.0259e-18
c762 n7__i137__x vss 97.6376e-18
c763 n67__vdd vss 59.9488e-18
c764 n11__net14 vss 177.233e-21
c765 n6__net31 vss 51.3429e-18
c766 n6__i137__x vss 83.2822e-18
c767 n13__net14 vss 102.818e-18
c768 n68__vdd vss 50.6095e-18
c769 n5__net15 vss 81.0259e-18
c770 n7__i136__x vss 97.6376e-18
c771 n69__vdd vss 59.9488e-18
c772 n11__net21 vss 177.233e-21
c773 n6__net15 vss 51.3429e-18
c774 n6__i136__x vss 83.2822e-18
c775 n13__net21 vss 102.818e-18
c776 n70__vdd vss 50.6095e-18
c777 n5__net22 vss 81.0259e-18
c778 n7__i135__x vss 97.6376e-18
c779 n71__vdd vss 59.9488e-18
c780 n11__net29 vss 177.233e-21
c781 n6__net22 vss 51.3429e-18
c782 n6__i135__x vss 83.2822e-18
c783 n13__net29 vss 102.818e-18
c784 n72__vdd vss 50.6095e-18
c785 n5__net30 vss 81.0259e-18
c786 n7__i134__x vss 97.6376e-18
c787 n73__vdd vss 59.9488e-18
c788 n11__net16 vss 177.233e-21
c789 n6__net30 vss 51.3429e-18
c790 n6__i134__x vss 83.2822e-18
c791 n13__net16 vss 102.818e-18
c792 n74__vdd vss 50.6095e-18
c793 n5__net17 vss 81.0259e-18
c794 n7__i133__x vss 97.6376e-18
c795 n75__vdd vss 59.9488e-18
c796 n11__net9 vss 177.233e-21
c797 n6__net17 vss 51.3429e-18
c798 n6__i133__x vss 83.2822e-18
c799 n13__net9 vss 102.818e-18
c800 n76__vdd vss 50.6095e-18
c801 n5__net10 vss 81.0259e-18
c802 n7__i132__x vss 97.6376e-18
c803 n77__vdd vss 59.9488e-18
c804 n11__net19 vss 177.233e-21
c805 n6__net10 vss 51.3429e-18
c806 n6__i132__x vss 83.2822e-18
c807 n13__net19 vss 102.818e-18
c808 n78__vdd vss 50.6095e-18
c809 n5__net20 vss 81.0259e-18
c810 n7__i131__x vss 97.6376e-18
c811 n79__vdd vss 59.9488e-18
c812 n11__net26 vss 177.233e-21
c813 n6__net20 vss 51.3429e-18
c814 n6__i131__x vss 83.2822e-18
c815 n13__net26 vss 102.881e-18
c816 n80__vdd vss 50.3673e-18
c817 n5__net27 vss 80.3824e-18
c818 n7__i130__x vss 96.7718e-18
c819 n81__vdd vss 38.2391e-18
c820 n6__net27 vss 51.3958e-18
c821 n6__i130__x vss 82.1963e-18
c822 n2__i130__x vss 28.0752e-18
c823 n2__i131__x vss 28.0618e-18
c824 n2__i132__x vss 28.0618e-18
c825 n2__i133__x vss 28.0618e-18
c826 n5__i130__x vss 38.0807e-18
c827 n7__net26 vss 24.3568e-18
c828 n2__i134__x vss 28.0618e-18
c829 n10__net26 vss 79.1441e-18
c830 n4__net27 vss 78.5197e-18
c831 n5__i131__x vss 37.0279e-18
c832 n7__net19 vss 24.2092e-18
c833 n2__i135__x vss 28.0618e-18
c834 n10__net19 vss 79.2224e-18
c835 n4__net20 vss 81.3179e-18
c836 n5__i132__x vss 37.0279e-18
c837 n7__net9 vss 24.2092e-18
c838 n2__i136__x vss 28.0618e-18
c839 n10__net9 vss 79.2224e-18
c840 n4__net10 vss 81.3179e-18
c841 n5__i133__x vss 37.0279e-18
c842 n7__net16 vss 24.2092e-18
c843 n2__i137__x vss 28.0618e-18
c844 n10__net16 vss 79.2224e-18
c845 n4__net17 vss 81.3179e-18
c846 n5__i134__x vss 37.0279e-18
c847 n7__net29 vss 24.2092e-18
c848 n2__i138__x vss 28.0618e-18
c849 n10__net29 vss 79.2224e-18
c850 n4__net30 vss 81.3179e-18
c851 n5__i135__x vss 37.0279e-18
c852 n7__net21 vss 24.2092e-18
c853 n2__i139__x vss 28.0618e-18
c854 n10__net21 vss 79.2224e-18
c855 n4__net22 vss 81.3179e-18
c856 n5__i136__x vss 37.0279e-18
c857 n7__net14 vss 24.2092e-18
c858 n2__i140__x vss 28.0618e-18
c859 n10__net14 vss 79.2224e-18
c860 n4__net15 vss 81.3179e-18
c861 n5__i137__x vss 37.0279e-18
c862 n7__net23 vss 24.2092e-18
c863 n2__i141__x vss 28.0618e-18
c864 n10__net23 vss 79.2224e-18
c865 n4__net31 vss 81.3179e-18
c866 n5__i138__x vss 37.0279e-18
c867 n7__net25 vss 24.2092e-18
c868 n2__i142__x vss 28.0618e-18
c869 n10__net25 vss 79.2224e-18
c870 n4__net11 vss 81.3179e-18
c871 n5__i139__x vss 37.0279e-18
c872 n7__net12 vss 24.2092e-18
c873 n2__i143__x vss 28.0618e-18
c874 n10__net12 vss 79.2224e-18
c875 n4__net5 vss 81.3179e-18
c876 n5__i140__x vss 37.0279e-18
c877 n7__net6 vss 24.2092e-18
c878 n2__i144__x vss 28.0618e-18
c879 n10__net6 vss 79.2224e-18
c880 n4__net1 vss 81.3179e-18
c881 n5__i141__x vss 37.0279e-18
c882 n7__net34 vss 24.2092e-18
c883 n2__i161__x vss 28.2332e-18
c884 n4__net2 vss 81.3179e-18
c885 n5__i142__x vss 37.0279e-18
c886 n7__net18 vss 24.2092e-18
c887 n4__net3 vss 81.3179e-18
c888 n5__i143__x vss 37.0279e-18
c889 n7__net13 vss 24.2092e-18
c890 n4__net4 vss 81.3179e-18
c891 n5__i144__x vss 37.0279e-18
c892 n7__net7 vss 22.6268e-18
c893 n4__net8 vss 80.9936e-18
c894 n5__i161__x vss 36.6858e-18
c895 n2__vdd vss 102.13e-18
c896 n3__vdd vss 49.0499e-18
c897 n4__vdd vss 65.6885e-18
c898 n5__vdd vss 113.63e-18
c899 n6__vdd vss 56.8054e-18
c900 n7__vdd vss 67.002e-18
c901 n8__vdd vss 113.63e-18
c902 n9__vdd vss 56.8054e-18
c903 n10__vdd vss 67.002e-18
c904 n11__vdd vss 113.63e-18
c905 n12__vdd vss 56.8054e-18
c906 n13__vdd vss 67.002e-18
c907 n14__vdd vss 113.63e-18
c908 n15__vdd vss 56.8054e-18
c909 n16__vdd vss 67.002e-18
c910 n17__vdd vss 113.63e-18
c911 n18__vdd vss 56.8054e-18
c912 n19__vdd vss 67.002e-18
c913 n20__vdd vss 113.63e-18
c914 n21__vdd vss 56.8054e-18
c915 n22__vdd vss 67.002e-18
c916 n23__vdd vss 113.63e-18
c917 n24__vdd vss 56.8054e-18
c918 n25__vdd vss 67.002e-18
c919 n26__vdd vss 113.63e-18
c920 n27__vdd vss 56.8054e-18
c921 n28__vdd vss 67.002e-18
c922 n29__vdd vss 113.63e-18
c923 n30__vdd vss 56.8054e-18
c924 n31__vdd vss 67.002e-18
c925 n32__vdd vss 113.63e-18
c926 n33__vdd vss 56.8054e-18
c927 n34__vdd vss 67.002e-18
c928 n35__vdd vss 113.63e-18
c929 n36__vdd vss 56.8054e-18
c930 n37__vdd vss 67.002e-18
c931 n38__vdd vss 113.63e-18
c932 n39__vdd vss 56.8054e-18
c933 n40__vdd vss 67.002e-18
c934 n41__vdd vss 113.63e-18
c935 n42__vdd vss 56.8054e-18
c936 n43__vdd vss 67.002e-18
c937 n44__vdd vss 113.63e-18
c938 n45__vdd vss 56.8115e-18
c939 n46__vdd vss 67.1233e-18
c940 n47__vdd vss 113.696e-18
c941 n48__vdd vss 47.1068e-18
c942 n13__net34 vss 79.2224e-18
c943 n13__net18 vss 79.2224e-18
c944 n13__net13 vss 79.2224e-18
c945 n13__net7 vss 71.3679e-18
c946 n145__clk1pt6g_b vss 152.598e-18
c947 n146__clk1pt6g_b vss 141.832e-18
c948 n147__clk1pt6g_b vss 141.832e-18
c949 n148__clk1pt6g_b vss 141.832e-18
c950 n149__clk1pt6g_b vss 141.832e-18
c951 n150__clk1pt6g_b vss 141.832e-18
c952 n151__clk1pt6g_b vss 141.832e-18
c953 n152__clk1pt6g_b vss 141.832e-18
c954 n153__clk1pt6g_b vss 141.832e-18
c955 n154__clk1pt6g_b vss 141.832e-18
c956 n155__clk1pt6g_b vss 141.832e-18
c957 n156__clk1pt6g_b vss 141.832e-18
c958 n157__clk1pt6g_b vss 141.832e-18
c959 n158__clk1pt6g_b vss 141.832e-18
c960 n159__clk1pt6g_b vss 144.23e-18
ri1 q1 n5__q1 135.9e-3
ri2 n5__q1 n4__q1 398.5e-3
ri3 q2 n5__q2 135.9e-3
ri4 n5__q2 n4__q2 398.5e-3
ri5 q3 n5__q3 135.9e-3
ri6 n5__q3 n4__q3 398.5e-3
ri7 q4 n5__q4 135.9e-3
ri8 n5__q4 n4__q4 398.5e-3
ri9 q5 n5__q5 135.9e-3
ri10 n5__q5 n4__q5 398.5e-3
ri11 q6 n5__q6 135.9e-3
ri12 n5__q6 n4__q6 398.5e-3
ri13 q7 n5__q7 135.9e-3
ri14 n5__q7 n4__q7 398.5e-3
ri15 q8 n5__q8 135.9e-3
ri16 n5__q8 n4__q8 398.5e-3
ri17 q9 n5__q9 135.9e-3
ri18 n5__q9 n4__q9 398.5e-3
ri19 q10 n5__q10 135.9e-3
ri20 n5__q10 n4__q10 398.5e-3
ri21 q11 n5__q11 135.9e-3
ri22 n5__q11 n4__q11 398.5e-3
ri23 q12 n8__q12 135.9e-3
ri24 n8__q12 n7__q12 398.5e-3
ri25 q13 n8__q13 135.9e-3
ri26 n8__q13 n7__q13 398.5e-3
ri27 q14 n8__q14 135.9e-3
ri28 n8__q14 n7__q14 398.5e-3
ri29 q15 n8__q15 135.9e-3
ri30 n8__q15 n7__q15 398.5e-3
ri31 n75__clk100m n74__clk100m 618.5e-3
ri32 n74__clk100m n73__clk100m 618.5e-3
ri33 n73__clk100m n69__clk100m 618.5e-3
ri34 n69__clk100m n64__clk100m 618.5e-3
ri35 n64__clk100m n59__clk100m 618.5e-3
ri36 n59__clk100m n54__clk100m 618.5e-3
ri37 n54__clk100m n49__clk100m 618.5e-3
ri38 n49__clk100m n44__clk100m 618.5e-3
ri39 n44__clk100m n39__clk100m 618.5e-3
ri40 n39__clk100m n34__clk100m 618.5e-3
ri41 n34__clk100m n29__clk100m 618.5e-3
ri42 n29__clk100m n24__clk100m 618.5e-3
ri43 n24__clk100m n19__clk100m 618.5e-3
ri44 n19__clk100m n14__clk100m 618.5e-3
ri45 n14__clk100m clk100m 1.022
ri46 n176__clk1pt6g n175__clk1pt6g 618.5e-3
ri47 n175__clk1pt6g n174__clk1pt6g 618.5e-3
ri48 n174__clk1pt6g n173__clk1pt6g 618.5e-3
ri49 n173__clk1pt6g n147__clk1pt6g 618.5e-3
ri50 n147__clk1pt6g n138__clk1pt6g 618.5e-3
ri51 n138__clk1pt6g n127__clk1pt6g 618.5e-3
ri52 n127__clk1pt6g n116__clk1pt6g 618.5e-3
ri53 n116__clk1pt6g n105__clk1pt6g 618.5e-3
ri54 n105__clk1pt6g n94__clk1pt6g 618.5e-3
ri55 n94__clk1pt6g n83__clk1pt6g 618.5e-3
ri56 n83__clk1pt6g n72__clk1pt6g 618.5e-3
ri57 n72__clk1pt6g n61__clk1pt6g 618.5e-3
ri58 n61__clk1pt6g n50__clk1pt6g 618.5e-3
ri59 n50__clk1pt6g n39__clk1pt6g 618.5e-3
ri60 n39__clk1pt6g n28__clk1pt6g 618.5e-3
ri61 n28__clk1pt6g clk1pt6g 1.1416
rj1 n3__q1 n4__q1 1
rj2 n13__clk100m n14__clk100m 500e-3
rj3 n5__q1 n8__q1 1
rj4 n26__clk1pt6g n28__clk1pt6g 1
rj5 n27__clk1pt6g_b n23__clk1pt6g_b 841.9e-3
rj6 n25__clk1pt6g n21__clk1pt6g 1.6922
rj7 n9__net26 n10__net26 793.3e-3
rj8 n10__net26 n3__net26 990.9e-3
rj9 n10__net26 n8__net26 553.6e-3
rj10 n3__q2 n4__q2 1
rj11 n18__clk100m n19__clk100m 500e-3
rj12 n5__q2 n8__q2 1
rj13 n37__clk1pt6g n39__clk1pt6g 1
rj14 n36__clk1pt6g_b n32__clk1pt6g_b 841.9e-3
rj15 n36__clk1pt6g n32__clk1pt6g 1.6922
rj16 n9__net19 n10__net19 793.3e-3
rj17 n10__net19 n3__net19 990.9e-3
rj18 n10__net19 n8__net19 553.6e-3
rj19 n3__q3 n4__q3 1
rj20 n23__clk100m n24__clk100m 500e-3
rj21 n5__q3 n8__q3 1
rj22 n48__clk1pt6g n50__clk1pt6g 1
rj23 n45__clk1pt6g_b n41__clk1pt6g_b 841.9e-3
rj24 n47__clk1pt6g n43__clk1pt6g 1.6922
rj25 n9__net9 n10__net9 793.3e-3
rj26 n10__net9 n3__net9 990.9e-3
rj27 n10__net9 n8__net9 553.6e-3
rj28 n3__q4 n4__q4 1
rj29 n28__clk100m n29__clk100m 500e-3
rj30 n5__q4 n8__q4 1
rj31 n59__clk1pt6g n61__clk1pt6g 1
rj32 n54__clk1pt6g_b n50__clk1pt6g_b 841.9e-3
rj33 n58__clk1pt6g n54__clk1pt6g 1.6922
rj34 n9__net16 n10__net16 793.3e-3
rj35 n10__net16 n3__net16 990.9e-3
rj36 n10__net16 n8__net16 553.6e-3
rj37 n3__q5 n4__q5 1
rj38 n33__clk100m n34__clk100m 500e-3
rj39 n5__q5 n8__q5 1
rj40 n70__clk1pt6g n72__clk1pt6g 1
rj41 n63__clk1pt6g_b n59__clk1pt6g_b 841.9e-3
rj42 n69__clk1pt6g n65__clk1pt6g 1.6922
rj43 n9__net29 n10__net29 793.3e-3
rj44 n10__net29 n3__net29 990.9e-3
rj45 n10__net29 n8__net29 553.6e-3
rj46 n3__q6 n4__q6 1
rj47 n38__clk100m n39__clk100m 500e-3
rj48 n5__q6 n8__q6 1
rj49 n81__clk1pt6g n83__clk1pt6g 1
rj50 n72__clk1pt6g_b n68__clk1pt6g_b 841.9e-3
rj51 n80__clk1pt6g n76__clk1pt6g 1.6922
rj52 n9__net21 n10__net21 793.3e-3
rj53 n10__net21 n3__net21 990.9e-3
rj54 n10__net21 n8__net21 553.6e-3
rj55 n3__q7 n4__q7 1
rj56 n43__clk100m n44__clk100m 500e-3
rj57 n5__q7 n8__q7 1
rj58 n92__clk1pt6g n94__clk1pt6g 1
rj59 n81__clk1pt6g_b n77__clk1pt6g_b 841.9e-3
rj60 n91__clk1pt6g n87__clk1pt6g 1.6922
rj61 n9__net14 n10__net14 793.3e-3
rj62 n10__net14 n3__net14 990.9e-3
rj63 n10__net14 n8__net14 553.6e-3
rj64 n3__q8 n4__q8 1
rj65 n48__clk100m n49__clk100m 500e-3
rj66 n5__q8 n8__q8 1
rj67 n103__clk1pt6g n105__clk1pt6g 1
rj68 n90__clk1pt6g_b n86__clk1pt6g_b 841.9e-3
rj69 n102__clk1pt6g n98__clk1pt6g 1.6922
rj70 n9__net23 n10__net23 793.3e-3
rj71 n10__net23 n3__net23 990.9e-3
rj72 n10__net23 n8__net23 553.6e-3
rj73 n3__q9 n4__q9 1
rj74 n53__clk100m n54__clk100m 500e-3
rj75 n5__q9 n8__q9 1
rj76 n114__clk1pt6g n116__clk1pt6g 1
rj77 n99__clk1pt6g_b n95__clk1pt6g_b 841.9e-3
rj78 n113__clk1pt6g n109__clk1pt6g 1.6922
rj79 n9__net25 n10__net25 793.3e-3
rj80 n10__net25 n3__net25 990.9e-3
rj81 n10__net25 n8__net25 553.6e-3
rj82 n3__q10 n4__q10 1
rj83 n58__clk100m n59__clk100m 500e-3
rj84 n5__q10 n8__q10 1
rj85 n125__clk1pt6g n127__clk1pt6g 1
rj86 n108__clk1pt6g_b n104__clk1pt6g_b 841.9e-3
rj87 n124__clk1pt6g n120__clk1pt6g 1.6922
rj88 n9__net12 n10__net12 793.3e-3
rj89 n10__net12 n3__net12 990.9e-3
rj90 n10__net12 n8__net12 553.6e-3
rj91 n3__q11 n4__q11 1
rj92 n63__clk100m n64__clk100m 500e-3
rj93 n5__q11 n8__q11 1
rj94 n136__clk1pt6g n138__clk1pt6g 1
rj95 n117__clk1pt6g_b n113__clk1pt6g_b 841.9e-3
rj96 n135__clk1pt6g n131__clk1pt6g 1.6922
rj97 n9__net6 n10__net6 793.3e-3
rj98 n10__net6 n3__net6 990.9e-3
rj99 n10__net6 n8__net6 553.6e-3
rj100 n3__q12 n7__q12 1
rj101 n68__clk100m n69__clk100m 500e-3
rj102 n8__q12 n6__q12 1
rj103 n146__clk1pt6g n147__clk1pt6g 1
rj104 n126__clk1pt6g_b n122__clk1pt6g_b 841.9e-3
rj105 n148__clk1pt6g n142__clk1pt6g 1.6922
rj106 n9__net34 n13__net34 793.3e-3
rj107 n13__net34 n3__net34 990.9e-3
rj108 n13__net34 n8__net34 553.6e-3
rj109 n3__q13 n7__q13 1
rj110 n70__clk100m n73__clk100m 500e-3
rj111 n8__q13 n6__q13 1
rj112 n156__clk1pt6g n173__clk1pt6g 1
rj113 n132__clk1pt6g_b n131__clk1pt6g_b 841.9e-3
rj114 n155__clk1pt6g n153__clk1pt6g 1.6922
rj115 n9__net18 n13__net18 793.3e-3
rj116 n13__net18 n3__net18 990.9e-3
rj117 n13__net18 n8__net18 553.6e-3
rj118 n3__q14 n7__q14 1
rj119 n71__clk100m n74__clk100m 500e-3
rj120 n8__q14 n6__q14 1
rj121 n161__clk1pt6g n174__clk1pt6g 1
rj122 n136__clk1pt6g_b n135__clk1pt6g_b 841.9e-3
rj123 n160__clk1pt6g n158__clk1pt6g 1.6922
rj124 n9__net13 n13__net13 793.3e-3
rj125 n13__net13 n3__net13 990.9e-3
rj126 n13__net13 n8__net13 553.6e-3
rj127 n3__q15 n7__q15 1
rj128 n72__clk100m n75__clk100m 500e-3
rj129 n8__q15 n6__q15 1
rj130 n166__clk1pt6g n175__clk1pt6g 1
rj131 n140__clk1pt6g_b n139__clk1pt6g_b 841.9e-3
rj132 n165__clk1pt6g n163__clk1pt6g 1.6922
rj133 n9__net7 n13__net7 793.3e-3
rj134 n13__net7 n3__net7 990.9e-3
rj135 n13__net7 n8__net7 553.6e-3
rj136 n142__clk1pt6g_b n145__clk1pt6g_b 1.2118
rj137 n145__clk1pt6g_b n146__clk1pt6g_b 652.4e-3
rj138 n146__clk1pt6g_b n147__clk1pt6g_b 652.4e-3
rj139 n147__clk1pt6g_b n148__clk1pt6g_b 652.4e-3
rj140 n148__clk1pt6g_b n149__clk1pt6g_b 652.4e-3
rj141 n149__clk1pt6g_b n150__clk1pt6g_b 652.4e-3
rj142 n150__clk1pt6g_b n151__clk1pt6g_b 652.4e-3
rj143 n151__clk1pt6g_b n152__clk1pt6g_b 652.4e-3
rj144 n152__clk1pt6g_b n153__clk1pt6g_b 652.4e-3
rj145 n153__clk1pt6g_b n154__clk1pt6g_b 652.4e-3
rj146 n154__clk1pt6g_b n155__clk1pt6g_b 652.4e-3
rj147 n155__clk1pt6g_b n156__clk1pt6g_b 652.4e-3
rj148 n156__clk1pt6g_b n157__clk1pt6g_b 652.4e-3
rj149 n157__clk1pt6g_b n158__clk1pt6g_b 652.4e-3
rj150 n158__clk1pt6g_b n159__clk1pt6g_b 648.9e-3
rj151 n159__clk1pt6g_b clk1pt6g_b 866e-3
rj152 n145__clk1pt6g_b n137__clk1pt6g_b 556e-3
rj153 n146__clk1pt6g_b n133__clk1pt6g_b 556e-3
rj154 n147__clk1pt6g_b n129__clk1pt6g_b 556e-3
rj155 n148__clk1pt6g_b n120__clk1pt6g_b 556e-3
rj156 n149__clk1pt6g_b n111__clk1pt6g_b 556e-3
rj157 n150__clk1pt6g_b n102__clk1pt6g_b 556e-3
rj158 n151__clk1pt6g_b n93__clk1pt6g_b 556e-3
rj159 n152__clk1pt6g_b n84__clk1pt6g_b 556e-3
rj160 n153__clk1pt6g_b n75__clk1pt6g_b 556e-3
rj161 n154__clk1pt6g_b n66__clk1pt6g_b 556e-3
rj162 n155__clk1pt6g_b n57__clk1pt6g_b 556e-3
rj163 n156__clk1pt6g_b n48__clk1pt6g_b 556e-3
rj164 n157__clk1pt6g_b n39__clk1pt6g_b 556e-3
rj165 n158__clk1pt6g_b n30__clk1pt6g_b 556e-3
rj166 n159__clk1pt6g_b n21__clk1pt6g_b 556e-3
rj167 n172__clk1pt6g n176__clk1pt6g 1
rj168 n144__clk1pt6g_b n143__clk1pt6g_b 841.9e-3
rj169 n170__clk1pt6g n169__clk1pt6g 1.6922
rk1 n2__q0 q0 45.1771
rk2 n2__clk1pt6g n21__clk1pt6g 3.07e-3
rk4 n3__clk1pt6g_b n21__clk1pt6g_b 3.325e-3
rk6 n1__clk1pt6g_b n23__clk1pt6g_b 558.1e-3
rk7 n2__net26 n3__net26 4.839e-3
rk8 net26 n2__net26 75
rk9 n2__q1 n3__q1 13.46e-3
rk10 n1__q1 n2__q1 31
rk11 n3__i130__x n5__i130__x 87.67e-3
rk12 n5__i130__x n6__i130__x 75.2443
rk13 n5__i130__x n7__i130__x 31.3501
rk14 n13__clk100m n3__clk100m 504.6e-3
rk15 n5__net26 n6__net26 2.638e-3
rk16 n7__net26 n8__net26 2.638e-3
rk17 n6__net26 n7__net26 15.6e-3
rk18 n4__net26 n5__net26 31
rk19 n7__q1 n8__q1 6.992e-3
rk20 n6__q1 n7__q1 75
rk21 n3__clk1pt6g n25__clk1pt6g 4.839e-3
rk22 n5__clk1pt6g n26__clk1pt6g 3.325e-3
rk24 n27__clk1pt6g_b n5__clk1pt6g_b 3.325e-3
rk25 n9__net26 n12__net26 49.38e-3
rk26 n12__net26 n13__net26 75.5713
rk27 n11__net26 n12__net26 31
rk28 n2__net27 n4__net27 521.4e-3
rk29 n4__net27 n5__net27 31.2629
rk30 n4__net27 n6__net27 75.1285
rk31 n7__clk1pt6g n32__clk1pt6g 3.07e-3
rk33 n8__clk1pt6g_b n30__clk1pt6g_b 3.325e-3
rk35 n6__clk1pt6g_b n32__clk1pt6g_b 558.1e-3
rk36 n2__net19 n3__net19 4.839e-3
rk37 net19 n2__net19 75
rk38 n2__q2 n3__q2 13.46e-3
rk39 n1__q2 n2__q2 31
rk40 n3__i131__x n5__i131__x 87.67e-3
rk41 n5__i131__x n6__i131__x 75.2443
rk42 n5__i131__x n7__i131__x 31.3501
rk43 n18__clk100m n6__clk100m 504.6e-3
rk44 n5__net19 n6__net19 2.638e-3
rk45 n7__net19 n8__net19 2.638e-3
rk46 n6__net19 n7__net19 15.6e-3
rk47 n4__net19 n5__net19 31
rk48 n7__q2 n8__q2 6.992e-3
rk49 n6__q2 n7__q2 75
rk50 n8__clk1pt6g n36__clk1pt6g 4.839e-3
rk51 n10__clk1pt6g n37__clk1pt6g 3.325e-3
rk53 n36__clk1pt6g_b n10__clk1pt6g_b 3.325e-3
rk54 n9__net19 n12__net19 49.38e-3
rk55 n12__net19 n13__net19 75.5713
rk56 n11__net19 n12__net19 31
rk57 n2__net20 n4__net20 521.4e-3
rk58 n4__net20 n5__net20 31.2629
rk59 n4__net20 n6__net20 75.1285
rk60 n12__clk1pt6g n43__clk1pt6g 3.07e-3
rk62 n13__clk1pt6g_b n39__clk1pt6g_b 3.325e-3
rk64 n11__clk1pt6g_b n41__clk1pt6g_b 558.1e-3
rk65 n2__net9 n3__net9 4.839e-3
rk66 net9 n2__net9 75
rk67 n2__q3 n3__q3 13.46e-3
rk68 n1__q3 n2__q3 31
rk69 n3__i132__x n5__i132__x 87.67e-3
rk70 n5__i132__x n6__i132__x 75.2443
rk71 n5__i132__x n7__i132__x 31.3501
rk72 n23__clk100m n9__clk100m 504.6e-3
rk73 n5__net9 n6__net9 2.638e-3
rk74 n7__net9 n8__net9 2.638e-3
rk75 n6__net9 n7__net9 15.6e-3
rk76 n4__net9 n5__net9 31
rk77 n7__q3 n8__q3 6.992e-3
rk78 n6__q3 n7__q3 75
rk79 n13__clk1pt6g n47__clk1pt6g 4.839e-3
rk80 n15__clk1pt6g n48__clk1pt6g 3.325e-3
rk82 n45__clk1pt6g_b n15__clk1pt6g_b 3.325e-3
rk83 n9__net9 n12__net9 49.38e-3
rk84 n12__net9 n13__net9 75.5713
rk85 n11__net9 n12__net9 31
rk86 n2__net10 n4__net10 521.4e-3
rk87 n4__net10 n5__net10 31.2629
rk88 n4__net10 n6__net10 75.1285
rk89 n17__clk1pt6g n54__clk1pt6g 3.07e-3
rk91 n18__clk1pt6g_b n48__clk1pt6g_b 3.325e-3
rk93 n16__clk1pt6g_b n50__clk1pt6g_b 558.1e-3
rk94 n2__net16 n3__net16 4.839e-3
rk95 net16 n2__net16 75
rk96 n2__q4 n3__q4 13.46e-3
rk97 n1__q4 n2__q4 31
rk98 n3__i133__x n5__i133__x 87.67e-3
rk99 n5__i133__x n6__i133__x 75.2443
rk100 n5__i133__x n7__i133__x 31.3501
rk101 n28__clk100m n12__clk100m 504.6e-3
rk102 n5__net16 n6__net16 2.638e-3
rk103 n7__net16 n8__net16 2.638e-3
rk104 n6__net16 n7__net16 15.6e-3
rk105 n4__net16 n5__net16 31
rk106 n7__q4 n8__q4 6.992e-3
rk107 n6__q4 n7__q4 75
rk108 n18__clk1pt6g n58__clk1pt6g 4.839e-3
rk109 n20__clk1pt6g n59__clk1pt6g 3.325e-3
rk111 n54__clk1pt6g_b n20__clk1pt6g_b 3.325e-3
rk112 n9__net16 n12__net16 49.38e-3
rk113 n12__net16 n13__net16 75.5713
rk114 n11__net16 n12__net16 31
rk115 n2__net17 n4__net17 521.4e-3
rk116 n4__net17 n5__net17 31.2629
rk117 n4__net17 n6__net17 75.1285
rk118 n24__clk1pt6g n65__clk1pt6g 3.07e-3
rk120 n26__clk1pt6g_b n57__clk1pt6g_b 3.325e-3
rk122 n24__clk1pt6g_b n59__clk1pt6g_b 558.1e-3
rk123 n2__net29 n3__net29 4.839e-3
rk124 net29 n2__net29 75
rk125 n2__q5 n3__q5 13.46e-3
rk126 n1__q5 n2__q5 31
rk127 n3__i134__x n5__i134__x 87.67e-3
rk128 n5__i134__x n6__i134__x 75.2443
rk129 n5__i134__x n7__i134__x 31.3501
rk130 n33__clk100m n17__clk100m 504.6e-3
rk131 n5__net29 n6__net29 2.638e-3
rk132 n7__net29 n8__net29 2.638e-3
rk133 n6__net29 n7__net29 15.6e-3
rk134 n4__net29 n5__net29 31
rk135 n7__q5 n8__q5 6.992e-3
rk136 n6__q5 n7__q5 75
rk137 n29__clk1pt6g n69__clk1pt6g 4.839e-3
rk138 n31__clk1pt6g n70__clk1pt6g 3.325e-3
rk140 n63__clk1pt6g_b n29__clk1pt6g_b 3.325e-3
rk141 n9__net29 n12__net29 49.38e-3
rk142 n12__net29 n13__net29 75.5713
rk143 n11__net29 n12__net29 31
rk144 n2__net30 n4__net30 521.4e-3
rk145 n4__net30 n5__net30 31.2629
rk146 n4__net30 n6__net30 75.1285
rk147 n35__clk1pt6g n76__clk1pt6g 3.07e-3
rk149 n35__clk1pt6g_b n66__clk1pt6g_b 3.325e-3
rk151 n33__clk1pt6g_b n68__clk1pt6g_b 558.1e-3
rk152 n2__net21 n3__net21 4.839e-3
rk153 net21 n2__net21 75
rk154 n2__q6 n3__q6 13.46e-3
rk155 n1__q6 n2__q6 31
rk156 n3__i135__x n5__i135__x 87.67e-3
rk157 n5__i135__x n6__i135__x 75.2443
rk158 n5__i135__x n7__i135__x 31.3501
rk159 n38__clk100m n22__clk100m 504.6e-3
rk160 n5__net21 n6__net21 2.638e-3
rk161 n7__net21 n8__net21 2.638e-3
rk162 n6__net21 n7__net21 15.6e-3
rk163 n4__net21 n5__net21 31
rk164 n7__q6 n8__q6 6.992e-3
rk165 n6__q6 n7__q6 75
rk166 n40__clk1pt6g n80__clk1pt6g 4.839e-3
rk167 n42__clk1pt6g n81__clk1pt6g 3.325e-3
rk169 n72__clk1pt6g_b n38__clk1pt6g_b 3.325e-3
rk170 n9__net21 n12__net21 49.38e-3
rk171 n12__net21 n13__net21 75.5713
rk172 n11__net21 n12__net21 31
rk173 n2__net22 n4__net22 521.4e-3
rk174 n4__net22 n5__net22 31.2629
rk175 n4__net22 n6__net22 75.1285
rk176 n46__clk1pt6g n87__clk1pt6g 3.07e-3
rk178 n44__clk1pt6g_b n75__clk1pt6g_b 3.325e-3
rk180 n42__clk1pt6g_b n77__clk1pt6g_b 558.1e-3
rk181 n2__net14 n3__net14 4.839e-3
rk182 net14 n2__net14 75
rk183 n2__q7 n3__q7 13.46e-3
rk184 n1__q7 n2__q7 31
rk185 n3__i136__x n5__i136__x 87.67e-3
rk186 n5__i136__x n6__i136__x 75.2443
rk187 n5__i136__x n7__i136__x 31.3501
rk188 n43__clk100m n27__clk100m 504.6e-3
rk189 n5__net14 n6__net14 2.638e-3
rk190 n7__net14 n8__net14 2.638e-3
rk191 n6__net14 n7__net14 15.6e-3
rk192 n4__net14 n5__net14 31
rk193 n7__q7 n8__q7 6.992e-3
rk194 n6__q7 n7__q7 75
rk195 n51__clk1pt6g n91__clk1pt6g 4.839e-3
rk196 n53__clk1pt6g n92__clk1pt6g 3.325e-3
rk198 n81__clk1pt6g_b n47__clk1pt6g_b 3.325e-3
rk199 n9__net14 n12__net14 49.38e-3
rk200 n12__net14 n13__net14 75.5713
rk201 n11__net14 n12__net14 31
rk202 n2__net15 n4__net15 521.4e-3
rk203 n4__net15 n5__net15 31.2629
rk204 n4__net15 n6__net15 75.1285
rk205 n57__clk1pt6g n98__clk1pt6g 3.07e-3
rk207 n53__clk1pt6g_b n84__clk1pt6g_b 3.325e-3
rk209 n51__clk1pt6g_b n86__clk1pt6g_b 558.1e-3
rk210 n2__net23 n3__net23 4.839e-3
rk211 net23 n2__net23 75
rk212 n2__q8 n3__q8 13.46e-3
rk213 n1__q8 n2__q8 31
rk214 n3__i137__x n5__i137__x 87.67e-3
rk215 n5__i137__x n6__i137__x 75.2443
rk216 n5__i137__x n7__i137__x 31.3501
rk217 n48__clk100m n32__clk100m 504.6e-3
rk218 n5__net23 n6__net23 2.638e-3
rk219 n7__net23 n8__net23 2.638e-3
rk220 n6__net23 n7__net23 15.6e-3
rk221 n4__net23 n5__net23 31
rk222 n7__q8 n8__q8 6.992e-3
rk223 n6__q8 n7__q8 75
rk224 n62__clk1pt6g n102__clk1pt6g 4.839e-3
rk225 n64__clk1pt6g n103__clk1pt6g 3.325e-3
rk227 n90__clk1pt6g_b n56__clk1pt6g_b 3.325e-3
rk228 n9__net23 n12__net23 49.38e-3
rk229 n12__net23 n13__net23 75.5713
rk230 n11__net23 n12__net23 31
rk231 n2__net31 n4__net31 521.4e-3
rk232 n4__net31 n5__net31 31.2629
rk233 n4__net31 n6__net31 75.1285
rk234 n68__clk1pt6g n109__clk1pt6g 3.07e-3
rk236 n62__clk1pt6g_b n93__clk1pt6g_b 3.325e-3
rk238 n60__clk1pt6g_b n95__clk1pt6g_b 558.1e-3
rk239 n2__net25 n3__net25 4.839e-3
rk240 net25 n2__net25 75
rk241 n2__q9 n3__q9 13.46e-3
rk242 n1__q9 n2__q9 31
rk243 n3__i138__x n5__i138__x 87.67e-3
rk244 n5__i138__x n6__i138__x 75.2443
rk245 n5__i138__x n7__i138__x 31.3501
rk246 n53__clk100m n37__clk100m 504.6e-3
rk247 n5__net25 n6__net25 2.638e-3
rk248 n7__net25 n8__net25 2.638e-3
rk249 n6__net25 n7__net25 15.6e-3
rk250 n4__net25 n5__net25 31
rk251 n7__q9 n8__q9 6.992e-3
rk252 n6__q9 n7__q9 75
rk253 n73__clk1pt6g n113__clk1pt6g 4.839e-3
rk254 n75__clk1pt6g n114__clk1pt6g 3.325e-3
rk256 n99__clk1pt6g_b n65__clk1pt6g_b 3.325e-3
rk257 n9__net25 n12__net25 49.38e-3
rk258 n12__net25 n13__net25 75.5713
rk259 n11__net25 n12__net25 31
rk260 n2__net11 n4__net11 521.4e-3
rk261 n4__net11 n5__net11 31.2629
rk262 n4__net11 n6__net11 75.1285
rk263 n79__clk1pt6g n120__clk1pt6g 3.07e-3
rk265 n71__clk1pt6g_b n102__clk1pt6g_b 3.325e-3
rk267 n69__clk1pt6g_b n104__clk1pt6g_b 558.1e-3
rk268 n2__net12 n3__net12 4.839e-3
rk269 net12 n2__net12 75
rk270 n2__q10 n3__q10 13.46e-3
rk271 n1__q10 n2__q10 31
rk272 n3__i139__x n5__i139__x 87.67e-3
rk273 n5__i139__x n6__i139__x 75.2443
rk274 n5__i139__x n7__i139__x 31.3501
rk275 n58__clk100m n42__clk100m 504.6e-3
rk276 n5__net12 n6__net12 2.638e-3
rk277 n7__net12 n8__net12 2.638e-3
rk278 n6__net12 n7__net12 15.6e-3
rk279 n4__net12 n5__net12 31
rk280 n7__q10 n8__q10 6.992e-3
rk281 n6__q10 n7__q10 75
rk282 n84__clk1pt6g n124__clk1pt6g 4.839e-3
rk283 n86__clk1pt6g n125__clk1pt6g 3.325e-3
rk285 n108__clk1pt6g_b n74__clk1pt6g_b 3.325e-3
rk286 n9__net12 n12__net12 49.38e-3
rk287 n12__net12 n13__net12 75.5713
rk288 n11__net12 n12__net12 31
rk289 n2__net5 n4__net5 521.4e-3
rk290 n4__net5 n5__net5 31.2629
rk291 n4__net5 n6__net5 75.1285
rk292 n90__clk1pt6g n131__clk1pt6g 3.07e-3
rk294 n80__clk1pt6g_b n111__clk1pt6g_b 3.325e-3
rk296 n78__clk1pt6g_b n113__clk1pt6g_b 558.1e-3
rk297 n2__net6 n3__net6 4.839e-3
rk298 net6 n2__net6 75
rk299 n2__q11 n3__q11 13.46e-3
rk300 n1__q11 n2__q11 31
rk301 n3__i140__x n5__i140__x 87.67e-3
rk302 n5__i140__x n6__i140__x 75.2443
rk303 n5__i140__x n7__i140__x 31.3501
rk304 n63__clk100m n47__clk100m 504.6e-3
rk305 n5__net6 n6__net6 2.638e-3
rk306 n7__net6 n8__net6 2.638e-3
rk307 n6__net6 n7__net6 15.6e-3
rk308 n4__net6 n5__net6 31
rk309 n7__q11 n8__q11 6.992e-3
rk310 n6__q11 n7__q11 75
rk311 n95__clk1pt6g n135__clk1pt6g 4.839e-3
rk312 n97__clk1pt6g n136__clk1pt6g 3.325e-3
rk314 n117__clk1pt6g_b n83__clk1pt6g_b 3.325e-3
rk315 n9__net6 n12__net6 49.38e-3
rk316 n12__net6 n13__net6 75.5713
rk317 n11__net6 n12__net6 31
rk318 n2__net1 n4__net1 521.4e-3
rk319 n4__net1 n5__net1 31.2629
rk320 n4__net1 n6__net1 75.1285
rk321 n101__clk1pt6g n142__clk1pt6g 3.07e-3
rk323 n89__clk1pt6g_b n120__clk1pt6g_b 3.325e-3
rk325 n87__clk1pt6g_b n122__clk1pt6g_b 558.1e-3
rk326 n2__net34 n3__net34 4.839e-3
rk327 net34 n2__net34 75
rk328 n2__q12 n3__q12 13.46e-3
rk329 n1__q12 n2__q12 31
rk330 n3__i141__x n5__i141__x 87.67e-3
rk331 n5__i141__x n6__i141__x 75.2443
rk332 n5__i141__x n7__i141__x 31.3501
rk333 n68__clk100m n52__clk100m 504.6e-3
rk334 n5__net34 n6__net34 2.638e-3
rk335 n7__net34 n8__net34 2.638e-3
rk336 n6__net34 n7__net34 15.6e-3
rk337 n4__net34 n5__net34 31
rk338 n5__q12 n6__q12 6.992e-3
rk339 n4__q12 n5__q12 75
rk340 n106__clk1pt6g n148__clk1pt6g 4.839e-3
rk341 n108__clk1pt6g n146__clk1pt6g 3.325e-3
rk343 n126__clk1pt6g_b n92__clk1pt6g_b 3.325e-3
rk344 n9__net34 n11__net34 49.38e-3
rk345 n11__net34 n12__net34 75.5713
rk346 n10__net34 n11__net34 31
rk347 n2__net2 n4__net2 521.4e-3
rk348 n4__net2 n5__net2 31.2629
rk349 n4__net2 n6__net2 75.1285
rk350 n112__clk1pt6g n153__clk1pt6g 3.07e-3
rk352 n98__clk1pt6g_b n129__clk1pt6g_b 3.325e-3
rk354 n96__clk1pt6g_b n131__clk1pt6g_b 558.1e-3
rk355 n2__net18 n3__net18 4.839e-3
rk356 net18 n2__net18 75
rk357 n2__q13 n3__q13 13.46e-3
rk358 n1__q13 n2__q13 31
rk359 n3__i142__x n5__i142__x 87.67e-3
rk360 n5__i142__x n6__i142__x 75.2443
rk361 n5__i142__x n7__i142__x 31.3501
rk362 n70__clk100m n57__clk100m 504.6e-3
rk363 n5__net18 n6__net18 2.638e-3
rk364 n7__net18 n8__net18 2.638e-3
rk365 n6__net18 n7__net18 15.6e-3
rk366 n4__net18 n5__net18 31
rk367 n5__q13 n6__q13 6.992e-3
rk368 n4__q13 n5__q13 75
rk369 n117__clk1pt6g n155__clk1pt6g 4.839e-3
rk370 n119__clk1pt6g n156__clk1pt6g 3.325e-3
rk372 n132__clk1pt6g_b n101__clk1pt6g_b 3.325e-3
rk373 n9__net18 n11__net18 49.38e-3
rk374 n11__net18 n12__net18 75.5713
rk375 n10__net18 n11__net18 31
rk376 n2__net3 n4__net3 521.4e-3
rk377 n4__net3 n5__net3 31.2629
rk378 n4__net3 n6__net3 75.1285
rk379 n123__clk1pt6g n158__clk1pt6g 3.07e-3
rk381 n107__clk1pt6g_b n133__clk1pt6g_b 3.325e-3
rk383 n105__clk1pt6g_b n135__clk1pt6g_b 558.1e-3
rk384 n2__net13 n3__net13 4.839e-3
rk385 net13 n2__net13 75
rk386 n2__q14 n3__q14 13.46e-3
rk387 n1__q14 n2__q14 31
rk388 n3__i143__x n5__i143__x 87.67e-3
rk389 n5__i143__x n6__i143__x 75.2443
rk390 n5__i143__x n7__i143__x 31.3501
rk391 n71__clk100m n62__clk100m 504.6e-3
rk392 n5__net13 n6__net13 2.638e-3
rk393 n7__net13 n8__net13 2.638e-3
rk394 n6__net13 n7__net13 15.6e-3
rk395 n4__net13 n5__net13 31
rk396 n5__q14 n6__q14 6.992e-3
rk397 n4__q14 n5__q14 75
rk398 n128__clk1pt6g n160__clk1pt6g 4.839e-3
rk399 n130__clk1pt6g n161__clk1pt6g 3.325e-3
rk401 n136__clk1pt6g_b n110__clk1pt6g_b 3.325e-3
rk402 n9__net13 n11__net13 49.38e-3
rk403 n11__net13 n12__net13 75.5713
rk404 n10__net13 n11__net13 31
rk405 n2__net4 n4__net4 521.4e-3
rk406 n4__net4 n5__net4 31.2629
rk407 n4__net4 n6__net4 75.1285
rk408 n134__clk1pt6g n163__clk1pt6g 3.07e-3
rk410 n116__clk1pt6g_b n137__clk1pt6g_b 3.325e-3
rk412 n114__clk1pt6g_b n139__clk1pt6g_b 558.1e-3
rk413 n2__net7 n3__net7 4.839e-3
rk414 net7 n2__net7 75
rk415 n2__q15 n3__q15 13.46e-3
rk416 n1__q15 n2__q15 31
rk417 n3__i144__x n5__i144__x 87.67e-3
rk418 n5__i144__x n6__i144__x 75.2443
rk419 n5__i144__x n7__i144__x 31.3501
rk420 n72__clk100m n67__clk100m 504.6e-3
rk421 n5__net7 n6__net7 2.638e-3
rk422 n7__net7 n8__net7 2.638e-3
rk423 n6__net7 n7__net7 15.6e-3
rk424 n4__net7 n5__net7 31
rk425 n5__q15 n6__q15 6.992e-3
rk426 n4__q15 n5__q15 75
rk427 n139__clk1pt6g n165__clk1pt6g 4.839e-3
rk428 n141__clk1pt6g n166__clk1pt6g 3.325e-3
rk430 n140__clk1pt6g_b n119__clk1pt6g_b 3.325e-3
rk431 n9__net7 n11__net7 49.38e-3
rk432 n11__net7 n12__net7 75.5738
rk433 n10__net7 n11__net7 31
rk434 n44__clk100m_b n41__clk100m_b 1.0295
rk435 n41__clk100m_b n38__clk100m_b 1.0295
rk436 n38__clk100m_b n35__clk100m_b 1.0295
rk437 n35__clk100m_b n32__clk100m_b 1.0295
rk438 n32__clk100m_b n29__clk100m_b 1.0295
rk439 n29__clk100m_b n26__clk100m_b 1.0295
rk440 n26__clk100m_b n23__clk100m_b 1.0295
rk441 n23__clk100m_b n20__clk100m_b 1.0295
rk442 n20__clk100m_b n17__clk100m_b 1.0295
rk443 n17__clk100m_b n14__clk100m_b 1.0295
rk444 n14__clk100m_b n11__clk100m_b 1.0295
rk445 n11__clk100m_b n8__clk100m_b 1.0295
rk446 n8__clk100m_b n5__clk100m_b 1.0295
rk447 n5__clk100m_b n2__clk100m_b 1.0295
rk448 n2__clk100m_b clk100m_b 179e-3
rk449 n2__net8 n4__net8 521.4e-3
rk450 n4__net8 n5__net8 31.2629
rk451 n4__net8 n6__net8 75.1285
rk453 n169__clk1pt6g n145__clk1pt6g 3.07e-3
rk455 n142__clk1pt6g_b n125__clk1pt6g_b 3.325e-3
rk456 n123__clk1pt6g_b n143__clk1pt6g_b 558.1e-3
rk457 n3__i161__x n5__i161__x 87.67e-3
rk458 n5__i161__x n6__i161__x 75.2443
rk459 n5__i161__x n7__i161__x 31.3501
rk460 n150__clk1pt6g n170__clk1pt6g 4.839e-3
rk462 n172__clk1pt6g n152__clk1pt6g 3.325e-3
rk463 n144__clk1pt6g_b n128__clk1pt6g_b 3.325e-3
rk464 n1__out out 31.2931
rk465 out n2__out 75.2672
rk467 n2__vdd n3__vdd 467.7e-3
rk468 n3__vdd n4__vdd 208.9e-3
rk469 n4__vdd n5__vdd 296.8e-3
rk470 n5__vdd n6__vdd 505.3e-3
rk471 n6__vdd n7__vdd 208.9e-3
rk472 n7__vdd n8__vdd 296.8e-3
rk473 n8__vdd n9__vdd 505.3e-3
rk474 n9__vdd n10__vdd 208.9e-3
rk475 n10__vdd n11__vdd 296.8e-3
rk476 n11__vdd n12__vdd 505.3e-3
rk477 n12__vdd n13__vdd 208.9e-3
rk478 n13__vdd n14__vdd 296.8e-3
rk479 n14__vdd n15__vdd 505.3e-3
rk480 n15__vdd n16__vdd 208.9e-3
rk481 n16__vdd n17__vdd 296.8e-3
rk482 n17__vdd n18__vdd 505.3e-3
rk483 n18__vdd n19__vdd 208.9e-3
rk484 n19__vdd n20__vdd 296.8e-3
rk485 n20__vdd n21__vdd 505.3e-3
rk486 n21__vdd n22__vdd 208.9e-3
rk487 n22__vdd n23__vdd 296.8e-3
rk488 n23__vdd n24__vdd 505.3e-3
rk489 n24__vdd n25__vdd 208.9e-3
rk490 n25__vdd n26__vdd 296.8e-3
rk491 n26__vdd n27__vdd 505.3e-3
rk492 n27__vdd n28__vdd 208.9e-3
rk493 n28__vdd n29__vdd 296.8e-3
rk494 n29__vdd n30__vdd 505.3e-3
rk495 n30__vdd n31__vdd 208.9e-3
rk496 n31__vdd n32__vdd 296.8e-3
rk497 n32__vdd n33__vdd 505.3e-3
rk498 n33__vdd n34__vdd 208.9e-3
rk499 n34__vdd n35__vdd 296.8e-3
rk500 n35__vdd n36__vdd 505.3e-3
rk501 n36__vdd n37__vdd 208.9e-3
rk502 n37__vdd n38__vdd 296.8e-3
rk503 n38__vdd n39__vdd 505.3e-3
rk504 n39__vdd n40__vdd 208.9e-3
rk505 n40__vdd n41__vdd 296.8e-3
rk506 n41__vdd n42__vdd 505.3e-3
rk507 n42__vdd n43__vdd 208.9e-3
rk508 n43__vdd n44__vdd 296.8e-3
rk509 n44__vdd n45__vdd 505.3e-3
rk510 n45__vdd n46__vdd 208.9e-3
rk511 n46__vdd n47__vdd 296.8e-3
rk512 n47__vdd n48__vdd 505.3e-3
rk513 n48__vdd vdd 73.77e-3
rk514 n2__vdd n49__vdd 31.1437
rk515 n3__vdd n50__vdd 31.1437
rk516 n4__vdd n51__vdd 75.1555
rk517 n5__vdd n52__vdd 31.1437
rk518 n6__vdd n53__vdd 31.1437
rk519 n7__vdd n51__vdd 75.1555
rk520 n8__vdd n54__vdd 31.1437
rk521 n9__vdd n55__vdd 31.1437
rk522 n10__vdd n51__vdd 75.1555
rk523 n11__vdd n56__vdd 31.1437
rk524 n12__vdd n57__vdd 31.1437
rk525 n13__vdd n51__vdd 75.1555
rk526 n14__vdd n58__vdd 31.1437
rk527 n15__vdd n59__vdd 31.1437
rk528 n16__vdd n51__vdd 75.1555
rk529 n17__vdd n60__vdd 31.1437
rk530 n18__vdd n61__vdd 31.1437
rk531 n19__vdd n51__vdd 75.1555
rk532 n20__vdd n62__vdd 31.1437
rk533 n21__vdd n63__vdd 31.1437
rk534 n22__vdd n51__vdd 75.1555
rk535 n23__vdd n64__vdd 31.1437
rk536 n24__vdd n65__vdd 31.1437
rk537 n25__vdd n51__vdd 75.1555
rk538 n26__vdd n66__vdd 31.1437
rk539 n27__vdd n67__vdd 31.1437
rk540 n28__vdd n51__vdd 75.1555
rk541 n29__vdd n68__vdd 31.1437
rk542 n30__vdd n69__vdd 31.1437
rk543 n31__vdd n51__vdd 75.1555
rk544 n32__vdd n70__vdd 31.1437
rk545 n33__vdd n71__vdd 31.1437
rk546 n34__vdd n51__vdd 75.1555
rk547 n35__vdd n72__vdd 31.1437
rk548 n36__vdd n73__vdd 31.1437
rk549 n37__vdd n51__vdd 75.1555
rk550 n38__vdd n74__vdd 31.1437
rk551 n39__vdd n75__vdd 31.1437
rk552 n40__vdd n51__vdd 75.1555
rk553 n41__vdd n76__vdd 31.1437
rk554 n42__vdd n77__vdd 31.1437
rk555 n43__vdd n51__vdd 75.1555
rk556 n44__vdd n78__vdd 31.1437
rk557 n45__vdd n79__vdd 31.1437
rk558 n46__vdd n51__vdd 75.1555
rk559 n47__vdd n80__vdd 31.1437
rk560 n48__vdd n81__vdd 31.1326
rk561 n1__vss n2__vss 75.0939
rk562 n2__vss n3__vss 3.106
rk563 n3__vss n4__vss 1.157
rk564 n4__vss n5__vss 1.157
rk565 n5__vss n6__vss 1.157
rk566 n6__vss n7__vss 1.157
rk567 n7__vss n8__vss 1.157
rk568 n8__vss n9__vss 1.157
rk569 n9__vss n10__vss 1.157
rk570 n10__vss n11__vss 1.157
rk571 n11__vss n12__vss 1.157
rk572 n12__vss n13__vss 1.157
rk573 n13__vss n14__vss 1.157
rk574 n14__vss n15__vss 1.157
rk575 n15__vss n16__vss 1.157
rk576 n16__vss n17__vss 1.157
rk577 n17__vss vss 1.767
rk578 n2__vss n18__vss 537.9e-3
rk579 n18__vss n19__vss 563.3e-3
rk580 n19__vss n20__vss 550.1e-3
rk581 n20__vss n21__vss 563.3e-3
rk582 n21__vss n22__vss 550.1e-3
rk583 n22__vss n23__vss 563.3e-3
rk584 n23__vss n24__vss 550.1e-3
rk585 n24__vss n25__vss 563.3e-3
rk586 n25__vss n26__vss 550.1e-3
rk587 n26__vss n27__vss 563.3e-3
rk588 n27__vss n28__vss 550.1e-3
rk589 n28__vss n29__vss 563.3e-3
rk590 n29__vss n30__vss 550.1e-3
rk591 n30__vss n31__vss 563.3e-3
rk592 n31__vss n32__vss 550.1e-3
rk593 n32__vss n33__vss 563.3e-3
rk594 n33__vss n34__vss 550.1e-3
rk595 n34__vss n35__vss 563.3e-3
rk596 n35__vss n36__vss 550.1e-3
rk597 n36__vss n37__vss 563.3e-3
rk598 n37__vss n38__vss 550.1e-3
rk599 n38__vss n39__vss 563.3e-3
rk600 n39__vss n40__vss 550.1e-3
rk601 n40__vss n41__vss 563.3e-3
rk602 n41__vss n42__vss 550.1e-3
rk603 n42__vss n43__vss 563.3e-3
rk604 n43__vss n44__vss 550.1e-3
rk605 n44__vss n45__vss 563.3e-3
rk606 n45__vss n46__vss 550.1e-3
rk607 n46__vss n47__vss 563.3e-3
rk608 n47__vss n48__vss 550.1e-3
rk610 n3__vss n50__vss 62.0754
rk611 n4__vss n50__vss 62.0754
rk612 n5__vss n50__vss 62.0754
rk613 n6__vss n50__vss 62.0754
rk614 n7__vss n50__vss 62.0754
rk615 n8__vss n50__vss 62.0754
rk616 n9__vss n50__vss 62.0754
rk617 n10__vss n50__vss 62.0754
rk618 n11__vss n50__vss 62.0754
rk619 n12__vss n50__vss 62.0754
rk620 n13__vss n50__vss 62.0754
rk621 n14__vss n50__vss 62.0754
rk622 n15__vss n50__vss 62.0754
rk623 n16__vss n50__vss 62.0754
rk624 n17__vss n50__vss 62.0754
rk625 n18__vss n51__vss 75.0902
rk626 n19__vss n52__vss 75.0939
rk627 n20__vss n53__vss 75.0902
rk628 n21__vss n54__vss 75.0939
rk629 n22__vss n55__vss 75.0902
rk630 n23__vss n56__vss 75.0939
rk631 n24__vss n57__vss 75.0902
rk632 n25__vss n58__vss 75.0939
rk633 n26__vss n59__vss 75.0902
rk634 n27__vss n60__vss 75.0939
rk635 n28__vss n61__vss 75.0902
rk636 n29__vss n62__vss 75.0939
rk637 n30__vss n63__vss 75.0902
rk638 n31__vss n64__vss 75.0939
rk639 n32__vss n65__vss 75.0902
rk640 n33__vss n66__vss 75.0939
rk641 n34__vss n67__vss 75.0902
rk642 n35__vss n68__vss 75.0939
rk643 n36__vss n69__vss 75.0902
rk644 n37__vss n70__vss 75.0939
rk645 n38__vss n71__vss 75.0902
rk646 n39__vss n72__vss 75.0939
rk647 n40__vss n73__vss 75.0902
rk648 n41__vss n74__vss 75.0939
rk649 n42__vss n75__vss 75.0902
rk650 n43__vss n76__vss 75.0939
rk651 n44__vss n77__vss 75.0902
rk652 n45__vss n78__vss 75.0939
rk653 n46__vss n79__vss 75.0902
rk654 n47__vss n80__vss 75.0939
rk655 n48__vss n81__vss 75.0884
rl1 n1__q0 n2__q0 85.7713
rl2 n2__q0 n3__q0 58.8482
rl3 n1__clk1pt6g n2__clk1pt6g 71.1559
rl4 n1__clk1pt6g_b n2__clk1pt6g_b 69.2328
rl5 n2__clk1pt6g_b n3__clk1pt6g_b 111.54
rl6 n1__clk100m_b n2__clk100m_b 113.464
rl7 n1__clk100m_b n3__clk100m_b 126.923
rl8 n1__clk100m n2__clk100m 126.923
rl9 n2__clk100m n3__clk100m 69.2328
rl10 i130__x n2__i130__x 99.7141
rl11 n2__i130__x n3__i130__x 50.1123
rl12 n2__i130__x n4__i130__x 65.0987
rl13 n4__clk1pt6g_b n5__clk1pt6g_b 71.1559
rl14 n3__clk1pt6g n4__clk1pt6g 69.2328
rl15 n4__clk1pt6g n5__clk1pt6g 111.54
rl16 net27 n2__net27 334.618
rl17 net27 n3__net27 173.077
rl18 n6__clk1pt6g n7__clk1pt6g 71.1559
rl19 n6__clk1pt6g_b n7__clk1pt6g_b 69.2328
rl20 n7__clk1pt6g_b n8__clk1pt6g_b 111.54
rl21 n4__clk100m_b n5__clk100m_b 113.464
rl22 n4__clk100m_b n6__clk100m_b 126.923
rl23 n4__clk100m n5__clk100m 126.923
rl24 n5__clk100m n6__clk100m 69.2328
rl25 i131__x n2__i131__x 99.7141
rl26 n2__i131__x n3__i131__x 50.1123
rl27 n2__i131__x n4__i131__x 65.0987
rl28 n9__clk1pt6g_b n10__clk1pt6g_b 71.1559
rl29 n8__clk1pt6g n9__clk1pt6g 69.2328
rl30 n9__clk1pt6g n10__clk1pt6g 111.54
rl31 net20 n2__net20 334.618
rl32 net20 n3__net20 173.077
rl33 n11__clk1pt6g n12__clk1pt6g 71.1559
rl34 n11__clk1pt6g_b n12__clk1pt6g_b 69.2328
rl35 n12__clk1pt6g_b n13__clk1pt6g_b 111.54
rl36 n7__clk100m_b n8__clk100m_b 113.464
rl37 n7__clk100m_b n9__clk100m_b 126.923
rl38 n7__clk100m n8__clk100m 126.923
rl39 n8__clk100m n9__clk100m 69.2328
rl40 i132__x n2__i132__x 99.7141
rl41 n2__i132__x n3__i132__x 50.1123
rl42 n2__i132__x n4__i132__x 65.0987
rl43 n14__clk1pt6g_b n15__clk1pt6g_b 71.1559
rl44 n13__clk1pt6g n14__clk1pt6g 69.2328
rl45 n14__clk1pt6g n15__clk1pt6g 111.54
rl46 net10 n2__net10 334.618
rl47 net10 n3__net10 173.077
rl48 n16__clk1pt6g n17__clk1pt6g 71.1559
rl49 n16__clk1pt6g_b n17__clk1pt6g_b 69.2328
rl50 n17__clk1pt6g_b n18__clk1pt6g_b 111.54
rl51 n10__clk100m_b n11__clk100m_b 113.464
rl52 n10__clk100m_b n12__clk100m_b 126.923
rl53 n10__clk100m n11__clk100m 126.923
rl54 n11__clk100m n12__clk100m 69.2328
rl55 i133__x n2__i133__x 99.7141
rl56 n2__i133__x n3__i133__x 50.1123
rl57 n2__i133__x n4__i133__x 65.0987
rl58 n19__clk1pt6g_b n20__clk1pt6g_b 71.1559
rl59 n18__clk1pt6g n19__clk1pt6g 69.2328
rl60 n19__clk1pt6g n20__clk1pt6g 111.54
rl61 net17 n2__net17 334.618
rl62 net17 n3__net17 173.077
rl63 n23__clk1pt6g n24__clk1pt6g 71.1559
rl64 n24__clk1pt6g_b n25__clk1pt6g_b 69.2328
rl65 n25__clk1pt6g_b n26__clk1pt6g_b 111.54
rl66 n13__clk100m_b n14__clk100m_b 113.464
rl67 n13__clk100m_b n15__clk100m_b 126.923
rl68 n15__clk100m n16__clk100m 126.923
rl69 n16__clk100m n17__clk100m 69.2328
rl70 i134__x n2__i134__x 99.7141
rl71 n2__i134__x n3__i134__x 50.1123
rl72 n2__i134__x n4__i134__x 65.0987
rl73 n28__clk1pt6g_b n29__clk1pt6g_b 71.1559
rl74 n29__clk1pt6g n30__clk1pt6g 69.2328
rl75 n30__clk1pt6g n31__clk1pt6g 111.54
rl76 net30 n2__net30 334.618
rl77 net30 n3__net30 173.077
rl78 n34__clk1pt6g n35__clk1pt6g 71.1559
rl79 n33__clk1pt6g_b n34__clk1pt6g_b 69.2328
rl80 n34__clk1pt6g_b n35__clk1pt6g_b 111.54
rl81 n16__clk100m_b n17__clk100m_b 113.464
rl82 n16__clk100m_b n18__clk100m_b 126.923
rl83 n20__clk100m n21__clk100m 126.923
rl84 n21__clk100m n22__clk100m 69.2328
rl85 i135__x n2__i135__x 99.7141
rl86 n2__i135__x n3__i135__x 50.1123
rl87 n2__i135__x n4__i135__x 65.0987
rl88 n37__clk1pt6g_b n38__clk1pt6g_b 71.1559
rl89 n40__clk1pt6g n41__clk1pt6g 69.2328
rl90 n41__clk1pt6g n42__clk1pt6g 111.54
rl91 net22 n2__net22 334.618
rl92 net22 n3__net22 173.077
rl93 n45__clk1pt6g n46__clk1pt6g 71.1559
rl94 n42__clk1pt6g_b n43__clk1pt6g_b 69.2328
rl95 n43__clk1pt6g_b n44__clk1pt6g_b 111.54
rl96 n19__clk100m_b n20__clk100m_b 113.464
rl97 n19__clk100m_b n21__clk100m_b 126.923
rl98 n25__clk100m n26__clk100m 126.923
rl99 n26__clk100m n27__clk100m 69.2328
rl100 i136__x n2__i136__x 99.7141
rl101 n2__i136__x n3__i136__x 50.1123
rl102 n2__i136__x n4__i136__x 65.0987
rl103 n46__clk1pt6g_b n47__clk1pt6g_b 71.1559
rl104 n51__clk1pt6g n52__clk1pt6g 69.2328
rl105 n52__clk1pt6g n53__clk1pt6g 111.54
rl106 net15 n2__net15 334.618
rl107 net15 n3__net15 173.077
rl108 n56__clk1pt6g n57__clk1pt6g 71.1559
rl109 n51__clk1pt6g_b n52__clk1pt6g_b 69.2328
rl110 n52__clk1pt6g_b n53__clk1pt6g_b 111.54
rl111 n22__clk100m_b n23__clk100m_b 113.464
rl112 n22__clk100m_b n24__clk100m_b 126.923
rl113 n30__clk100m n31__clk100m 126.923
rl114 n31__clk100m n32__clk100m 69.2328
rl115 i137__x n2__i137__x 99.7141
rl116 n2__i137__x n3__i137__x 50.1123
rl117 n2__i137__x n4__i137__x 65.0987
rl118 n55__clk1pt6g_b n56__clk1pt6g_b 71.1559
rl119 n62__clk1pt6g n63__clk1pt6g 69.2328
rl120 n63__clk1pt6g n64__clk1pt6g 111.54
rl121 net31 n2__net31 334.618
rl122 net31 n3__net31 173.077
rl123 n67__clk1pt6g n68__clk1pt6g 71.1559
rl124 n60__clk1pt6g_b n61__clk1pt6g_b 69.2328
rl125 n61__clk1pt6g_b n62__clk1pt6g_b 111.54
rl126 n25__clk100m_b n26__clk100m_b 113.464
rl127 n25__clk100m_b n27__clk100m_b 126.923
rl128 n35__clk100m n36__clk100m 126.923
rl129 n36__clk100m n37__clk100m 69.2328
rl130 i138__x n2__i138__x 99.7141
rl131 n2__i138__x n3__i138__x 50.1123
rl132 n2__i138__x n4__i138__x 65.0987
rl133 n64__clk1pt6g_b n65__clk1pt6g_b 71.1559
rl134 n73__clk1pt6g n74__clk1pt6g 69.2328
rl135 n74__clk1pt6g n75__clk1pt6g 111.54
rl136 net11 n2__net11 334.618
rl137 net11 n3__net11 173.077
rl138 n78__clk1pt6g n79__clk1pt6g 71.1559
rl139 n69__clk1pt6g_b n70__clk1pt6g_b 69.2328
rl140 n70__clk1pt6g_b n71__clk1pt6g_b 111.54
rl141 n28__clk100m_b n29__clk100m_b 113.464
rl142 n28__clk100m_b n30__clk100m_b 126.923
rl143 n40__clk100m n41__clk100m 126.923
rl144 n41__clk100m n42__clk100m 69.2328
rl145 i139__x n2__i139__x 99.7141
rl146 n2__i139__x n3__i139__x 50.1123
rl147 n2__i139__x n4__i139__x 65.0987
rl148 n73__clk1pt6g_b n74__clk1pt6g_b 71.1559
rl149 n84__clk1pt6g n85__clk1pt6g 69.2328
rl150 n85__clk1pt6g n86__clk1pt6g 111.54
rl151 net5 n2__net5 334.618
rl152 net5 n3__net5 173.077
rl153 n89__clk1pt6g n90__clk1pt6g 71.1559
rl154 n78__clk1pt6g_b n79__clk1pt6g_b 69.2328
rl155 n79__clk1pt6g_b n80__clk1pt6g_b 111.54
rl156 n31__clk100m_b n32__clk100m_b 113.464
rl157 n31__clk100m_b n33__clk100m_b 126.923
rl158 n45__clk100m n46__clk100m 126.923
rl159 n46__clk100m n47__clk100m 69.2328
rl160 i140__x n2__i140__x 99.7141
rl161 n2__i140__x n3__i140__x 50.1123
rl162 n2__i140__x n4__i140__x 65.0987
rl163 n82__clk1pt6g_b n83__clk1pt6g_b 71.1559
rl164 n95__clk1pt6g n96__clk1pt6g 69.2328
rl165 n96__clk1pt6g n97__clk1pt6g 111.54
rl166 net1 n2__net1 334.618
rl167 net1 n3__net1 173.077
rl168 n100__clk1pt6g n101__clk1pt6g 71.1559
rl169 n87__clk1pt6g_b n88__clk1pt6g_b 69.2328
rl170 n88__clk1pt6g_b n89__clk1pt6g_b 111.54
rl171 n34__clk100m_b n35__clk100m_b 113.464
rl172 n34__clk100m_b n36__clk100m_b 126.923
rl173 n50__clk100m n51__clk100m 126.923
rl174 n51__clk100m n52__clk100m 69.2328
rl175 i141__x n2__i141__x 99.7141
rl176 n2__i141__x n3__i141__x 50.1123
rl177 n2__i141__x n4__i141__x 65.0987
rl178 n91__clk1pt6g_b n92__clk1pt6g_b 71.1559
rl179 n106__clk1pt6g n107__clk1pt6g 69.2328
rl180 n107__clk1pt6g n108__clk1pt6g 111.54
rl181 net2 n2__net2 334.618
rl182 net2 n3__net2 173.077
rl183 n111__clk1pt6g n112__clk1pt6g 71.1559
rl184 n96__clk1pt6g_b n97__clk1pt6g_b 69.2328
rl185 n97__clk1pt6g_b n98__clk1pt6g_b 111.54
rl186 n37__clk100m_b n38__clk100m_b 113.464
rl187 n37__clk100m_b n39__clk100m_b 126.923
rl188 n55__clk100m n56__clk100m 126.923
rl189 n56__clk100m n57__clk100m 69.2328
rl190 i142__x n2__i142__x 99.7141
rl191 n2__i142__x n3__i142__x 50.1123
rl192 n2__i142__x n4__i142__x 65.0987
rl193 n100__clk1pt6g_b n101__clk1pt6g_b 71.1559
rl194 n117__clk1pt6g n118__clk1pt6g 69.2328
rl195 n118__clk1pt6g n119__clk1pt6g 111.54
rl196 net3 n2__net3 334.618
rl197 net3 n3__net3 173.077
rl198 n122__clk1pt6g n123__clk1pt6g 71.1559
rl199 n105__clk1pt6g_b n106__clk1pt6g_b 69.2328
rl200 n106__clk1pt6g_b n107__clk1pt6g_b 111.54
rl201 n40__clk100m_b n41__clk100m_b 113.464
rl202 n40__clk100m_b n42__clk100m_b 126.923
rl203 n60__clk100m n61__clk100m 126.923
rl204 n61__clk100m n62__clk100m 69.2328
rl205 i143__x n2__i143__x 99.7141
rl206 n2__i143__x n3__i143__x 50.1123
rl207 n2__i143__x n4__i143__x 65.0987
rl208 n109__clk1pt6g_b n110__clk1pt6g_b 71.1559
rl209 n128__clk1pt6g n129__clk1pt6g 69.2328
rl210 n129__clk1pt6g n130__clk1pt6g 111.54
rl211 net4 n2__net4 334.618
rl212 net4 n3__net4 173.077
rl213 n133__clk1pt6g n134__clk1pt6g 71.1559
rl214 n114__clk1pt6g_b n115__clk1pt6g_b 69.2328
rl215 n115__clk1pt6g_b n116__clk1pt6g_b 111.54
rl216 n43__clk100m_b n44__clk100m_b 113.464
rl217 n43__clk100m_b n45__clk100m_b 126.923
rl218 n65__clk100m n66__clk100m 126.923
rl219 n66__clk100m n67__clk100m 69.2328
rl220 i144__x n2__i144__x 99.7141
rl221 n2__i144__x n3__i144__x 50.1123
rl222 n2__i144__x n4__i144__x 65.0987
rl223 n118__clk1pt6g_b n119__clk1pt6g_b 71.1559
rl224 n139__clk1pt6g n140__clk1pt6g 69.2328
rl225 n140__clk1pt6g n141__clk1pt6g 111.54
rl226 net8 n2__net8 334.618
rl227 net8 n3__net8 173.077
rl228 n144__clk1pt6g n145__clk1pt6g 71.1559
rl229 n123__clk1pt6g_b n124__clk1pt6g_b 69.2328
rl230 n124__clk1pt6g_b n125__clk1pt6g_b 111.54
rl231 i161__x n2__i161__x 99.7141
rl232 n2__i161__x n3__i161__x 50.1123
rl233 n2__i161__x n4__i161__x 65.0987
rl234 n127__clk1pt6g_b n128__clk1pt6g_b 71.1559
rl235 n150__clk1pt6g n151__clk1pt6g 69.2328
rl236 n151__clk1pt6g n152__clk1pt6g 111.54
mi144__pm0 i144__net2 net4 n53__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi144__pm1 n7__i144__x n133__clk1pt6g i144__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi160__i0__pm0 n5__net8 n45__clk100m_b n1__q15 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi160__i1__pm0 n4__net7 n66__clk100m n5__net8 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi144__pm2 i144__net4 i144__x n52__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi144__pm3 n10__net7 n118__clk1pt6g_b i144__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__pm0 i161__net2 net8 n50__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__pm1 n7__i161__x n144__clk1pt6g i161__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__pm2 i161__net4 i161__x n49__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__pm3 n1__out n127__clk1pt6g_b i161__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__pm0 i143__net2 net3 n55__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__pm1 n7__i143__x n122__clk1pt6g i143__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi159__i0__pm0 n5__net4 n42__clk100m_b n1__q14 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi159__i1__pm0 n4__net13 n61__clk100m n5__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__pm2 i143__net4 i143__x n54__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__pm3 n10__net13 n109__clk1pt6g_b i143__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__pm0 i142__net2 net2 n57__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__pm1 n7__i142__x n111__clk1pt6g i142__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi158__i0__pm0 n5__net3 n39__clk100m_b n1__q13 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi158__i1__pm0 n4__net18 n56__clk100m n5__net3 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__pm2 i142__net4 i142__x n56__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__pm3 n10__net18 n100__clk1pt6g_b i142__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__pm0 i141__net2 net1 n59__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__pm1 n7__i141__x n100__clk1pt6g i141__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi157__i0__pm0 n5__net2 n36__clk100m_b n1__q12 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi157__i1__pm0 n4__net34 n51__clk100m n5__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__pm2 i141__net4 i141__x n58__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__pm3 n10__net34 n91__clk1pt6g_b i141__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__pm0 i140__net2 net5 n61__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__pm1 n7__i140__x n89__clk1pt6g i140__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi156__i0__pm0 n5__net1 n33__clk100m_b n1__q11 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi156__i1__pm0 n4__net6 n46__clk100m n5__net1 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__pm2 i140__net4 i140__x n60__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__pm3 n11__net6 n82__clk1pt6g_b i140__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__pm0 i139__net2 net11 n63__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__pm1 n7__i139__x n78__clk1pt6g i139__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi155__i0__pm0 n5__net5 n30__clk100m_b n1__q10 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi155__i1__pm0 n4__net12 n41__clk100m n5__net5 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__pm2 i139__net4 i139__x n62__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__pm3 n11__net12 n73__clk1pt6g_b i139__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__pm0 i138__net2 net31 n65__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__pm1 n7__i138__x n67__clk1pt6g i138__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi154__i0__pm0 n5__net11 n27__clk100m_b n1__q9 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi154__i1__pm0 n4__net25 n36__clk100m n5__net11 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__pm2 i138__net4 i138__x n64__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__pm3 n11__net25 n64__clk1pt6g_b i138__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__pm0 i137__net2 net15 n67__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__pm1 n7__i137__x n56__clk1pt6g i137__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi153__i0__pm0 n5__net31 n24__clk100m_b n1__q8 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi153__i1__pm0 n4__net23 n31__clk100m n5__net31 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__pm2 i137__net4 i137__x n66__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__pm3 n11__net23 n55__clk1pt6g_b i137__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__pm0 i136__net2 net22 n69__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__pm1 n7__i136__x n45__clk1pt6g i136__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi152__i0__pm0 n5__net15 n21__clk100m_b n1__q7 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi152__i1__pm0 n4__net14 n26__clk100m n5__net15 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__pm2 i136__net4 i136__x n68__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__pm3 n11__net14 n46__clk1pt6g_b i136__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__pm0 i135__net2 net30 n71__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__pm1 n7__i135__x n34__clk1pt6g i135__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi151__i0__pm0 n5__net22 n18__clk100m_b n1__q6 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi151__i1__pm0 n4__net21 n21__clk100m n5__net22 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__pm2 i135__net4 i135__x n70__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__pm3 n11__net21 n37__clk1pt6g_b i135__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__pm0 i134__net2 net17 n73__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__pm1 n7__i134__x n23__clk1pt6g i134__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi150__i0__pm0 n5__net30 n15__clk100m_b n1__q5 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi150__i1__pm0 n4__net29 n16__clk100m n5__net30 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__pm2 i134__net4 i134__x n72__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__pm3 n11__net29 n28__clk1pt6g_b i134__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__pm0 i133__net2 net10 n75__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__pm1 n7__i133__x n16__clk1pt6g i133__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi149__i0__pm0 n5__net17 n12__clk100m_b n1__q4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi149__i1__pm0 n4__net16 n11__clk100m n5__net17 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__pm2 i133__net4 i133__x n74__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__pm3 n11__net16 n19__clk1pt6g_b i133__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__pm0 i132__net2 net20 n77__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__pm1 n7__i132__x n11__clk1pt6g i132__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi148__i0__pm0 n5__net10 n9__clk100m_b n1__q3 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi148__i1__pm0 n4__net9 n8__clk100m n5__net10 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__pm2 i132__net4 i132__x n76__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__pm3 n11__net9 n14__clk1pt6g_b i132__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__pm0 i131__net2 net27 n79__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__pm1 n7__i131__x n6__clk1pt6g i131__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi147__i0__pm0 n5__net20 n6__clk100m_b n1__q2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi147__i1__pm0 n4__net19 n5__clk100m n5__net20 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__pm2 i131__net4 i131__x n78__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__pm3 n11__net19 n9__clk1pt6g_b i131__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__pm0 i130__net2 n1__q0 n81__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__pm1 n7__i130__x n1__clk1pt6g i130__net2 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi146__i0__pm0 n5__net27 n3__clk100m_b n1__q1 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi146__i1__pm0 n4__net26 n2__clk100m n5__net27 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__pm2 i130__net4 i130__x n80__vdd n51__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__pm3 n11__net26 n4__clk1pt6g_b i130__net4 n51__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi144__nm1 i144__net3 n3__net4 n53__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi144__nm0 n6__i144__x n115__clk1pt6g_b i144__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi160__i1__nm0 n6__net8 n43__clk100m_b net7 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi160__i0__nm0 n4__q15 n65__clk100m n6__net8 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi144__nm3 i144__net5 n4__i144__x n52__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi144__nm2 n12__net7 n140__clk1pt6g i144__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__nm1 i161__net3 n3__net8 n51__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__nm0 n6__i161__x n124__clk1pt6g_b i161__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__nm3 i161__net5 n4__i161__x n1__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi161__nm2 n2__out n151__clk1pt6g i161__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__nm1 i143__net3 n3__net3 n55__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__nm0 n6__i143__x n106__clk1pt6g_b i143__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi159__i1__nm0 n6__net4 n40__clk100m_b net13 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi159__i0__nm0 n4__q14 n60__clk100m n6__net4 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__nm3 i143__net5 n4__i143__x n54__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi143__nm2 n12__net13 n129__clk1pt6g i143__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__nm1 i142__net3 n3__net2 n57__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__nm0 n6__i142__x n97__clk1pt6g_b i142__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi158__i1__nm0 n6__net3 n37__clk100m_b net18 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi158__i0__nm0 n4__q13 n55__clk100m n6__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__nm3 i142__net5 n4__i142__x n56__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi142__nm2 n12__net18 n118__clk1pt6g i142__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__nm1 i141__net3 n3__net1 n59__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__nm0 n6__i141__x n88__clk1pt6g_b i141__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi157__i1__nm0 n6__net2 n34__clk100m_b net34 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi157__i0__nm0 n4__q12 n50__clk100m n6__net2 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__nm3 i141__net5 n4__i141__x n58__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi141__nm2 n12__net34 n107__clk1pt6g i141__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__nm1 i140__net3 n3__net5 n61__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__nm0 n6__i140__x n79__clk1pt6g_b i140__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi156__i1__nm0 n6__net1 n31__clk100m_b net6 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi156__i0__nm0 n6__q11 n45__clk100m n6__net1 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__nm3 i140__net5 n4__i140__x n60__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi140__nm2 n13__net6 n96__clk1pt6g i140__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__nm1 i139__net3 n3__net11 n63__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__nm0 n6__i139__x n70__clk1pt6g_b i139__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi155__i1__nm0 n6__net5 n28__clk100m_b net12 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi155__i0__nm0 n6__q10 n40__clk100m n6__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__nm3 i139__net5 n4__i139__x n62__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi139__nm2 n13__net12 n85__clk1pt6g i139__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__nm1 i138__net3 n3__net31 n65__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__nm0 n6__i138__x n61__clk1pt6g_b i138__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi154__i1__nm0 n6__net11 n25__clk100m_b net25 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi154__i0__nm0 n6__q9 n35__clk100m n6__net11 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__nm3 i138__net5 n4__i138__x n64__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi138__nm2 n13__net25 n74__clk1pt6g i138__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__nm1 i137__net3 n3__net15 n67__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__nm0 n6__i137__x n52__clk1pt6g_b i137__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi153__i1__nm0 n6__net31 n22__clk100m_b net23 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi153__i0__nm0 n6__q8 n30__clk100m n6__net31 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__nm3 i137__net5 n4__i137__x n66__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi137__nm2 n13__net23 n63__clk1pt6g i137__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__nm1 i136__net3 n3__net22 n69__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__nm0 n6__i136__x n43__clk1pt6g_b i136__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi152__i1__nm0 n6__net15 n19__clk100m_b net14 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi152__i0__nm0 n6__q7 n25__clk100m n6__net15 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__nm3 i136__net5 n4__i136__x n68__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi136__nm2 n13__net14 n52__clk1pt6g i136__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__nm1 i135__net3 n3__net30 n71__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__nm0 n6__i135__x n34__clk1pt6g_b i135__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi151__i1__nm0 n6__net22 n16__clk100m_b net21 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi151__i0__nm0 n6__q6 n20__clk100m n6__net22 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__nm3 i135__net5 n4__i135__x n70__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi135__nm2 n13__net21 n41__clk1pt6g i135__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__nm1 i134__net3 n3__net17 n73__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__nm0 n6__i134__x n25__clk1pt6g_b i134__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi150__i1__nm0 n6__net30 n13__clk100m_b net29 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi150__i0__nm0 n6__q5 n15__clk100m n6__net30 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__nm3 i134__net5 n4__i134__x n72__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi134__nm2 n13__net29 n30__clk1pt6g i134__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__nm1 i133__net3 n3__net10 n75__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__nm0 n6__i133__x n17__clk1pt6g_b i133__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi149__i1__nm0 n6__net17 n10__clk100m_b net16 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi149__i0__nm0 n6__q4 n10__clk100m n6__net17 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__nm3 i133__net5 n4__i133__x n74__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi133__nm2 n13__net16 n19__clk1pt6g i133__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__nm1 i132__net3 n3__net20 n77__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__nm0 n6__i132__x n12__clk1pt6g_b i132__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi148__i1__nm0 n6__net10 n7__clk100m_b net9 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi148__i0__nm0 n6__q3 n7__clk100m n6__net10 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__nm3 i132__net5 n4__i132__x n76__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi132__nm2 n13__net9 n14__clk1pt6g i132__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__nm1 i131__net3 n3__net27 n79__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__nm0 n6__i131__x n7__clk1pt6g_b i131__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi147__i1__nm0 n6__net20 n4__clk100m_b net19 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi147__i0__nm0 n6__q2 n4__clk100m n6__net20 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__nm3 i131__net5 n4__i131__x n78__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi131__nm2 n13__net19 n9__clk1pt6g i131__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__nm1 i130__net3 n3__q0 n81__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__nm0 n6__i130__x n2__clk1pt6g_b i130__net3 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi146__i1__nm0 n6__net27 n1__clk100m_b net26 n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi146__i0__nm0 n6__q1 n1__clk100m n6__net27 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__nm3 i130__net5 n4__i130__x n80__vss n50__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi130__nm2 n13__net26 n4__clk1pt6g i130__net5 n50__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
.END
