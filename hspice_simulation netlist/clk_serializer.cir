** Generated for: hspiceD
** Generated on: Dec  4 13:40:40 2023
** Design library name: ECE482final_cadence
** Design cell name: clock_serializer
** Design view name: av_extracted

.TEMP 25.0
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2

** Library name: ECE482final_cadence
** Cell name: clock_serializer
** View name: av_extracted
c1 vdd vss 4.90255e-18
c2 clk1pt6g vss 12.4851e-18
c3 en vss 12.9849e-18
c4 en_b vss 23.3806e-18
c5 ext_tx vss 12.7527e-18
c6 out0 vss 43.2551e-18
c7 out1 vss 44.2333e-18
c8 out10 vss 44.0035e-18
c9 out11 vss 44.0035e-18
c10 out12 vss 44.0035e-18
c11 out13 vss 44.1402e-18
c12 out14 vss 44.0035e-18
c13 out15 vss 44.0116e-18
c14 out2 vss 44.1402e-18
c15 out3 vss 44.1402e-18
c16 out4 vss 44.0035e-18
c17 out5 vss 44.1402e-18
c18 out6 vss 44.0035e-18
c19 out7 vss 43.9123e-18
c20 out8 vss 44.1402e-18
c21 out9 vss 44.0035e-18
c22 rst vss 148.284e-18
c23 rst_b vss 47.2776e-18
c24 net24 vss 43.7698e-18
c25 net21 vss 32.13e-18
c26 net22 vss 38.1585e-18
c27 net23 vss 75.4866e-18
c28 net1 vss 83.5117e-18
c29 clk100m vss 30.1299e-18
c30 i29__net27 vss 76.9964e-18
c31 clk100m_b vss 128.167e-18
c32 net18 vss 40.8533e-18
c33 i29__net20 vss 76.5913e-18
c34 i29__net10 vss 76.5913e-18
c35 i29__net17 vss 76.5913e-18
c36 i29__net30 vss 76.5913e-18
c37 i29__net22 vss 76.5913e-18
c38 i29__net15 vss 76.5913e-18
c39 i29__net31 vss 76.5913e-18
c40 i29__net11 vss 76.6031e-18
c41 i29__net5 vss 76.5913e-18
c42 i29__net1 vss 76.5952e-18
c43 i29__net2 vss 76.5952e-18
c44 i29__net3 vss 76.5952e-18
c45 i29__net4 vss 76.5913e-18
c46 i29__net8 vss 77.051e-18
c47 net29 vss 24.1105e-18
c48 net28 vss 57.4685e-18
c49 net20 vss 96.6811e-18
c50 net25 vss 43.8854e-18
c51 net11 vss 37.4286e-18
c52 net10 vss 37.4286e-18
c53 net9 vss 37.4286e-18
c54 net8 vss 37.4286e-18
c55 net6 vss 37.4286e-18
c56 net5 vss 31.8153e-18
c57 net4 vss 37.4286e-18
c58 net3 vss 37.3273e-18
c59 net2 vss 37.3273e-18
c60 net17 vss 31.8898e-18
c61 net16 vss 12.7331e-18
c62 net15 vss 37.3522e-18
c63 net14 vss 10.7692e-18
c64 net13 vss 37.4286e-18
c65 net12 vss 37.4286e-18
c66 avs31 vss 59.2118e-18
c67 avs164 vss 47.66e-18
c68 i29__i161__net5 vss 100.157e-18
c69 i29__i161__net4 vss 91.7398e-18
c70 i29__i161__x vss 42.7909e-18
c71 i29__i161__net3 vss 105.622e-18
c72 i29__i161__net2 vss 102.736e-18
c73 i33__d0 vss 93.3702e-18
c74 i33__xor2 vss 65.3461e-18
c75 i33__xor1 vss 20.5193e-18
c76 i33__i58__net2 vss 55.5051e-18
c77 i33__i58__net1 vss 30.7108e-18
c78 i33__i56__net2 vss 37.4517e-18
c79 i33__i56__net1 vss 30.1932e-18
c80 i33__i57__net2 vss 50.446e-18
c81 i33__i57__net1 vss 27.4291e-18
c82 i33__i0__net2 vss 105.568e-18
c83 i33__i0__x vss 47.6941e-18
c84 i33__i0__net4 vss 94.7141e-18
c85 i33__i0__net5 vss 100.805e-18
c86 i33__i0__net3 vss 107.26e-18
c87 i33__i0__net1 vss 38.2329e-18
c88 i33__i16__net2 vss 105.82e-18
c89 i33__i16__x vss 47.7157e-18
c90 i33__i16__net4 vss 94.4399e-18
c91 i33__i16__net5 vss 100.588e-18
c92 i33__i16__net3 vss 107.26e-18
c93 i33__i16__net1 vss 38.2233e-18
c94 i33__i18__net2 vss 105.731e-18
c95 i33__i18__x vss 47.7157e-18
c96 i33__i18__net4 vss 94.4399e-18
c97 i33__i18__net5 vss 100.588e-18
c98 i33__i18__net3 vss 107.26e-18
c99 i33__i18__net1 vss 38.2237e-18
c100 i33__i17__net2 vss 105.746e-18
c101 i33__i17__x vss 48.4966e-18
c102 i33__i17__net4 vss 96.0679e-18
c103 i33__i17__net5 vss 100.588e-18
c104 i33__i17__net3 vss 107.27e-18
c105 i33__i17__net1 vss 37.816e-18
c106 i33__i22__net2 vss 107.221e-18
c107 i33__i22__x vss 48.4966e-18
c108 i33__i22__net4 vss 96.1523e-18
c109 i33__i22__net5 vss 100.588e-18
c110 i33__i22__net3 vss 107.26e-18
c111 i33__i22__net1 vss 37.771e-18
c112 i33__i19__net2 vss 107.221e-18
c113 i33__i19__x vss 48.4966e-18
c114 i33__i19__net4 vss 96.1523e-18
c115 i33__i19__net5 vss 100.588e-18
c116 i33__i19__net3 vss 107.26e-18
c117 i33__i19__net1 vss 37.771e-18
c118 i33__i21__net2 vss 107.221e-18
c119 i33__i21__x vss 48.4966e-18
c120 i33__i21__net4 vss 96.1523e-18
c121 i33__i21__net5 vss 100.666e-18
c122 i33__i21__net3 vss 107.336e-18
c123 i33__i21__net1 vss 37.771e-18
c124 i33__i20__net2 vss 107.221e-18
c125 i33__i20__x vss 48.4966e-18
c126 i33__i20__net4 vss 96.1523e-18
c127 i33__i20__net5 vss 100.588e-18
c128 i33__i20__net3 vss 107.26e-18
c129 i33__i20__net1 vss 37.771e-18
c130 i33__i30__net2 vss 107.221e-18
c131 i33__i30__x vss 48.4966e-18
c132 i33__i30__net4 vss 96.1523e-18
c133 i33__i30__net5 vss 100.588e-18
c134 i33__i30__net3 vss 107.26e-18
c135 i33__i30__net1 vss 37.771e-18
c136 i33__i23__net2 vss 107.221e-18
c137 i33__i23__x vss 48.4966e-18
c138 i33__i23__net4 vss 96.1523e-18
c139 i33__i23__net5 vss 100.588e-18
c140 i33__i23__net3 vss 107.26e-18
c141 i33__i23__net1 vss 37.771e-18
c142 i33__i25__net2 vss 107.221e-18
c143 i33__i25__x vss 48.4966e-18
c144 i33__i25__net4 vss 96.1523e-18
c145 i33__i25__net5 vss 100.588e-18
c146 i33__i25__net3 vss 107.26e-18
c147 i33__i25__net1 vss 37.7733e-18
c148 i33__i24__net2 vss 107.221e-18
c149 i33__i24__x vss 48.4966e-18
c150 i33__i24__net4 vss 96.1523e-18
c151 i33__i24__net5 vss 100.588e-18
c152 i33__i24__net3 vss 107.141e-18
c153 i33__i24__net1 vss 37.771e-18
c154 i33__i29__net2 vss 105.85e-18
c155 i33__i29__x vss 48.1731e-18
c156 i33__i29__net4 vss 95.0502e-18
c157 i33__i29__net5 vss 101.81e-18
c158 i33__i29__net3 vss 109.61e-18
c159 i33__i29__net1 vss 37.771e-18
c160 i33__i26__net2 vss 105.85e-18
c161 i33__i26__x vss 48.1731e-18
c162 i33__i26__net4 vss 95.0502e-18
c163 i33__i26__net5 vss 102.003e-18
c164 i33__i26__net3 vss 110.017e-18
c165 i33__i26__net1 vss 37.771e-18
c166 i33__i28__net2 vss 105.278e-18
c167 i33__i28__x vss 48.2468e-18
c168 i33__i28__net4 vss 94.5872e-18
c169 i33__i28__net5 vss 103.09e-18
c170 i33__i28__net3 vss 109.723e-18
c171 i33__i28__net1 vss 38.0695e-18
c172 i33__i27__net2 vss 103.002e-18
c173 i33__i27__x vss 48.3833e-18
c174 i33__i27__net4 vss 92.6084e-18
c175 i33__i27__net5 vss 101.541e-18
c176 i33__i27__net3 vss 109.731e-18
c177 i33__i27__net1 vss 38.791e-18
c178 i40__i57__net5 vss 98.0251e-18
c179 i40__i57__net4 vss 93.8872e-18
c180 i40__i57__x vss 40.3192e-18
c181 i40__i57__net3 vss 98.0647e-18
c182 i40__i57__net2 vss 90.0442e-18
c183 i40__i56__net5 vss 98.1289e-18
c184 i40__i56__net4 vss 94.3635e-18
c185 i40__i56__x vss 39.9557e-18
c186 i40__i56__net3 vss 96.3617e-18
c187 i40__i56__net2 vss 90.5614e-18
c188 i40__i55__net5 vss 98.4707e-18
c189 i40__i55__net4 vss 94.493e-18
c190 i40__i55__x vss 40.0355e-18
c191 i40__i55__net3 vss 96.8786e-18
c192 i40__i55__net2 vss 90.1397e-18
c193 i40__i54__net5 vss 98.5863e-18
c194 i40__i54__net4 vss 94.1286e-18
c195 i40__i54__x vss 40.0761e-18
c196 i40__i54__net3 vss 97.505e-18
c197 i40__i54__net2 vss 90.522e-18
c198 i40__i53__net5 vss 96.9309e-18
c199 i40__i53__net4 vss 94.2546e-18
c200 i40__i53__x vss 39.9557e-18
c201 i40__i53__net3 vss 97.4839e-18
c202 i40__i53__net2 vss 90.4854e-18
c203 i40__i52__net5 vss 98.4156e-18
c204 i40__i52__net4 vss 94.4655e-18
c205 i40__i52__x vss 39.9604e-18
c206 i40__i52__net3 vss 96.7243e-18
c207 i40__i52__net2 vss 90.1622e-18
c208 i40__i51__net5 vss 98.2501e-18
c209 i40__i51__net4 vss 94.3275e-18
c210 i40__i51__x vss 40.0076e-18
c211 i40__i51__net3 vss 97.4577e-18
c212 i40__i51__net2 vss 90.5914e-18
c213 i40__i50__net5 vss 96.8795e-18
c214 i40__i50__net4 vss 94.2096e-18
c215 i40__i50__x vss 39.9557e-18
c216 i40__i50__net3 vss 97.6816e-18
c217 i40__i50__net2 vss 90.5742e-18
c218 i40__i49__net5 vss 98.3755e-18
c219 i40__i49__net4 vss 94.4472e-18
c220 i40__i49__x vss 39.9247e-18
c221 i40__i49__net3 vss 97.9886e-18
c222 i40__i49__net2 vss 90.1772e-18
c223 i40__i48__net5 vss 98.2086e-18
c224 i40__i48__net4 vss 94.3333e-18
c225 i40__i48__x vss 40.0076e-18
c226 i40__i48__net3 vss 97.4171e-18
c227 i40__i48__net2 vss 90.6376e-18
c228 i40__i47__net5 vss 97.9862e-18
c229 i40__i47__net4 vss 94.1796e-18
c230 i40__i47__x vss 38.4198e-18
c231 i40__i47__net3 vss 97.7514e-18
c232 i40__i47__net2 vss 90.5559e-18
c233 i40__i46__net5 vss 97.2195e-18
c234 i40__i46__net4 vss 94.4472e-18
c235 i40__i46__x vss 39.8685e-18
c236 i40__i46__net3 vss 98.1119e-18
c237 i40__i46__net2 vss 90.0933e-18
c238 i40__i45__net5 vss 98.1671e-18
c239 i40__i45__net4 vss 94.3464e-18
c240 i40__i45__x vss 40.0076e-18
c241 i40__i45__net3 vss 97.3764e-18
c242 i40__i45__net2 vss 90.6274e-18
c243 i40__i44__net5 vss 97.9506e-18
c244 i40__i44__net4 vss 94.1646e-18
c245 i40__i44__x vss 40.2195e-18
c246 i40__i44__net3 vss 97.8181e-18
c247 i40__i44__net2 vss 90.5378e-18
c248 i40__i43__net5 vss 98.0922e-18
c249 i40__i43__net4 vss 94.2382e-18
c250 i40__i43__x vss 38.7992e-18
c251 i40__i43__net3 vss 96.8786e-18
c252 i40__i43__net2 vss 90.0049e-18
c253 i40__i42__net5 vss 97.0729e-18
c254 i40__i42__net4 vss 94.1669e-18
c255 i40__i42__x vss 38.9336e-18
c256 i40__i42__net3 vss 95.7743e-18
c257 i40__i42__net2 vss 91.7884e-18
c258 i28__net7 vss 41.5922e-18
c259 i28__net2 vss 18.2619e-18
c260 i28__i50__net1 vss 24.9885e-18
c261 i28__i50__net2 vss 184.653e-18
c262 i28__net8 vss 28.7988e-18
c263 i28__net14 vss 87.3417e-18
c264 i28__net9 vss 30.8452e-18
c265 i28__net1 vss 39.4634e-18
c266 i28__net6 vss 53.3278e-18
c267 i28__net15 vss 36.2532e-18
c268 i28__net3 vss 30.3233e-18
c269 i28__net20 vss 216.117e-18
c270 i28__net17 vss 36.2651e-18
c271 i28__net12 vss 26.0536e-18
c272 i28__net23 vss 211.856e-18
c273 i28__net19 vss 37.0381e-18
c274 i28__net13 vss 25.9476e-18
c275 i28__net26 vss 323.322e-18
c276 i28__net5 vss 38.7964e-18
c277 i28__net11 vss 20.5509e-18
c278 i28__net4 vss 89.2163e-18
c279 i28__net10 vss 70.6261e-18
c280 i2__avs135 vss 272.42e-18
c281 i28__i53__net5 vss 36.8945e-18
c282 i28__i53__net4 vss 82.8262e-18
c283 i28__i53__x vss 57.1043e-18
c284 i28__i53__net2 vss 145.226e-18
c285 i28__i53__net3 vss 32.3303e-18
c286 i28__i51__net5 vss 37.48e-18
c287 i28__i51__net4 vss 74.9725e-18
c288 i28__i51__x vss 38.7101e-18
c289 i28__i51__net2 vss 151.482e-18
c290 i28__i51__net3 vss 38.8227e-18
c291 i28__i72__net5 vss 37.4737e-18
c292 i28__i72__net4 vss 76.9236e-18
c293 i28__i72__x vss 37.7292e-18
c294 i28__i72__net2 vss 155.13e-18
c295 i28__i72__net3 vss 39.109e-18
c296 i28__i71__net5 vss 37.48e-18
c297 i28__i71__net4 vss 76.083e-18
c298 i28__i71__x vss 36.5049e-18
c299 i28__i71__net2 vss 153.692e-18
c300 i28__i71__net3 vss 38.6312e-18
c301 i28__i70__net5 vss 37.4734e-18
c302 i28__i70__net4 vss 76.3062e-18
c303 i28__i70__x vss 36.2236e-18
c304 i28__i70__net2 vss 154.419e-18
c305 i28__i70__net3 vss 38.8199e-18
c306 i28__i52__net5 vss 40.548e-18
c307 i28__i52__net4 vss 80.6717e-18
c308 i28__i52__x vss 56.6579e-18
c309 i28__i52__net2 vss 48.2952e-18
c310 i28__i52__net3 vss 32.3806e-18
c311 i28__i69__net5 vss 37.4734e-18
c312 i28__i69__net4 vss 78.4584e-18
c313 i28__i69__x vss 36.544e-18
c314 i28__i69__net2 vss 151.393e-18
c315 i28__i69__net3 vss 39.8738e-18
c316 i29__i144__net2 vss 101.941e-18
c317 i29__i144__x vss 41.2801e-18
c318 i29__i144__net4 vss 92.8609e-18
c319 i29__net7 vss 86.5303e-18
c320 i29__i144__net3 vss 104.434e-18
c321 i29__i144__net5 vss 100.992e-18
c322 i29__i143__net2 vss 102.055e-18
c323 i29__i143__x vss 41.2838e-18
c324 i29__i143__net4 vss 92.8609e-18
c325 i29__net13 vss 86.345e-18
c326 i29__i143__net3 vss 104.617e-18
c327 i29__i143__net5 vss 100.459e-18
c328 i29__i142__net2 vss 102.038e-18
c329 i29__i142__x vss 41.2838e-18
c330 i29__i142__net4 vss 92.8609e-18
c331 i29__net18 vss 86.345e-18
c332 i29__i142__net3 vss 104.132e-18
c333 i29__i142__net5 vss 100.703e-18
c334 i29__i141__net2 vss 102.032e-18
c335 i29__i141__x vss 41.2838e-18
c336 i29__i141__net4 vss 92.8609e-18
c337 i29__net34 vss 86.345e-18
c338 i29__i141__net3 vss 104.308e-18
c339 i29__i141__net5 vss 100.717e-18
c340 i29__i140__net2 vss 101.996e-18
c341 i29__i140__x vss 41.2838e-18
c342 i29__i140__net4 vss 92.8609e-18
c343 i29__net6 vss 86.345e-18
c344 i29__i140__net3 vss 104.421e-18
c345 i29__i140__net5 vss 100.371e-18
c346 i29__i139__net2 vss 102.101e-18
c347 i29__i139__x vss 41.2838e-18
c348 i29__i139__net4 vss 92.966e-18
c349 i29__net12 vss 86.345e-18
c350 i29__i139__net3 vss 104.313e-18
c351 i29__i139__net5 vss 100.409e-18
c352 i29__i138__net2 vss 101.996e-18
c353 i29__i138__x vss 41.2838e-18
c354 i29__i138__net4 vss 92.966e-18
c355 i29__net25 vss 86.345e-18
c356 i29__i138__net3 vss 104.434e-18
c357 i29__i138__net5 vss 100.409e-18
c358 i29__i137__net2 vss 101.995e-18
c359 i29__i137__x vss 41.2838e-18
c360 i29__i137__net4 vss 92.8609e-18
c361 i29__net23 vss 86.345e-18
c362 i29__i137__net3 vss 104.732e-18
c363 i29__i137__net5 vss 100.669e-18
c364 i29__i136__net2 vss 102.024e-18
c365 i29__i136__x vss 41.2838e-18
c366 i29__i136__net4 vss 92.9578e-18
c367 i29__net14 vss 86.3396e-18
c368 i29__i136__net3 vss 104.517e-18
c369 i29__i136__net5 vss 100.661e-18
c370 i29__i135__net2 vss 102.017e-18
c371 i29__i135__x vss 41.2838e-18
c372 i29__i135__net4 vss 92.8609e-18
c373 i29__net21 vss 86.345e-18
c374 i29__i135__net3 vss 104.197e-18
c375 i29__i135__net5 vss 100.371e-18
c376 i29__i134__net2 vss 102.017e-18
c377 i29__i134__x vss 41.2838e-18
c378 i29__i134__net4 vss 92.9366e-18
c379 i29__i134__net3 vss 104.197e-18
c380 i29__i134__net5 vss 100.263e-18
c381 i29__i133__net2 vss 102.017e-18
c382 i29__i133__x vss 41.2838e-18
c383 i29__i133__net4 vss 92.9366e-18
c384 i29__net16 vss 86.345e-18
c385 i29__i133__net3 vss 104.894e-18
c386 i29__i133__net5 vss 100.803e-18
c387 i29__i132__net2 vss 102.035e-18
c388 i29__i132__x vss 41.2838e-18
c389 i29__i132__net4 vss 92.9591e-18
c390 i29__net9 vss 86.345e-18
c391 i29__i132__net3 vss 104.617e-18
c392 i29__i132__net5 vss 100.987e-18
c393 i29__i131__net2 vss 102.017e-18
c394 i29__i131__x vss 41.2838e-18
c395 i29__i131__net4 vss 92.9423e-18
c396 i29__net19 vss 86.345e-18
c397 i29__i131__net3 vss 104.248e-18
c398 i29__i131__net5 vss 100.452e-18
c399 i29__i130__net2 vss 103.795e-18
c400 i29__i130__x vss 41.8618e-18
c401 i29__i130__net4 vss 93.5137e-18
c402 i29__net26 vss 82.6189e-18
c403 i29__i130__net3 vss 100.367e-18
c404 i29__i130__net5 vss 100.263e-18
c405 n4__net28 vss 40.7138e-18
c406 n6__net25 vss 40.7684e-18
c407 n156__net23 vss 30.5545e-18
c408 n579__clk1pt6g vss 46.0739e-18
c409 n10__ext_tx vss 35.8085e-18
c410 n1__ext_tx vss 29.3595e-18
c411 n4__ext_tx vss 25.6057e-18
c412 n567__clk1pt6g vss 32.259e-18
c413 n129__net29 vss 44.1327e-18
c414 n7__net24 vss 41.6274e-18
c415 n4__out15 vss 40.1626e-18
c416 n147__net23 vss 30.3023e-18
c417 n557__clk1pt6g vss 47.2189e-18
c418 n341__clk100m vss 31.4027e-18
c419 n7__net21 vss 26.097e-18
c420 n232__clk100m_b vss 57.2374e-18
c421 n46__en vss 40.6948e-18
c422 n544__clk1pt6g vss 31.5345e-18
c423 n121__net29 vss 44.1262e-18
c424 n46__en_b vss 49.6056e-18
c425 n15__i28__net6 vss 26.4002e-18
c426 n4__out14 vss 40.4394e-18
c427 n223__clk100m_b vss 29.3367e-18
c428 n14__i28__net6 vss 29.4901e-18
c429 n138__net23 vss 30.5779e-18
c430 n6__i28__net6 vss 25.4372e-18
c431 n535__clk1pt6g vss 47.2189e-18
c432 n126__rst_b vss 31.6762e-18
c433 n5__i28__net6 vss 31.5657e-18
c434 n328__clk100m vss 32.3629e-18
c435 n202__rst vss 34.8147e-18
c436 n29__i28__net13 vss 30.0751e-18
c437 n221__clk100m_b vss 57.583e-18
c438 n323__clk100m vss 29.4339e-18
c439 n26__i28__net13 vss 14.4688e-18
c440 n43__en vss 40.8893e-18
c441 n528__clk1pt6g vss 14.8341e-18
c442 n518__clk1pt6g vss 31.5345e-18
c443 n112__net29 vss 44.1262e-18
c444 n43__en_b vss 49.5844e-18
c445 n526__clk1pt6g vss 28.5012e-18
c446 n4__out13 vss 40.8286e-18
c447 n209__clk100m_b vss 31.035e-18
c448 n6__i28__i51__x vss 26.8582e-18
c449 n6__i28__i52__x vss 28.2357e-18
c450 n129__net23 vss 30.5779e-18
c451 n509__clk1pt6g vss 47.2189e-18
c452 n116__rst_b vss 30.2734e-18
c453 n5__i28__i52__x vss 34.0687e-18
c454 n313__clk100m vss 32.3629e-18
c455 n6__i28__net11 vss 29.5638e-18
c456 n186__rst vss 34.726e-18
c457 n207__clk100m_b vss 57.3209e-18
c458 n3__i28__net11 vss 14.5796e-18
c459 n308__clk100m vss 29.8409e-18
c460 n61__net22 vss 14.6539e-18
c461 n40__en vss 40.8834e-18
c462 n494__clk1pt6g vss 31.5345e-18
c463 n103__net29 vss 44.1262e-18
c464 n59__net22 vss 28.287e-18
c465 n40__en_b vss 49.5844e-18
c466 n4__out12 vss 41.5628e-18
c467 n6__i28__net5 vss 27.9458e-18
c468 n195__clk100m_b vss 31.0295e-18
c469 n12__i28__net7 vss 28.9622e-18
c470 n120__net23 vss 30.5779e-18
c471 n487__clk1pt6g vss 47.2189e-18
c472 n11__i28__net7 vss 34.3223e-18
c473 n106__rst_b vss 30.2734e-18
c474 n297__clk100m vss 32.3629e-18
c475 n170__rst vss 34.726e-18
c476 n16__i28__net13 vss 27.3904e-18
c477 n193__clk100m_b vss 57.3209e-18
c478 n292__clk100m vss 29.8409e-18
c479 n478__clk1pt6g vss 14.8021e-18
c480 n17__i28__net13 vss 24.9621e-18
c481 n37__en vss 40.8834e-18
c482 n468__clk1pt6g vss 31.5345e-18
c483 n94__net29 vss 44.1262e-18
c484 n476__clk1pt6g vss 28.3482e-18
c485 n37__en_b vss 49.5844e-18
c486 n3__i28__net13 vss 12.224e-18
c487 n4__out11 vss 39.1664e-18
c488 n6__i28__i53__x vss 28.264e-18
c489 n179__clk100m_b vss 31.9853e-18
c490 n13__i28__net13 vss 15.8675e-18
c491 n111__net23 vss 30.5779e-18
c492 n461__clk1pt6g vss 47.2189e-18
c493 n5__i28__i53__x vss 31.9107e-18
c494 n96__rst_b vss 30.2734e-18
c495 n282__clk100m vss 32.3629e-18
c496 n154__rst vss 34.726e-18
c497 n29__i28__net12 vss 30.0297e-18
c498 n177__clk100m_b vss 57.4457e-18
c499 n49__net22 vss 14.687e-18
c500 n277__clk100m vss 30.6127e-18
c501 n26__i28__net12 vss 14.4688e-18
c502 n34__en vss 40.8834e-18
c503 n444__clk1pt6g vss 31.5345e-18
c504 n85__net29 vss 44.1262e-18
c505 n47__net22 vss 27.697e-18
c506 n34__en_b vss 49.5844e-18
c507 n4__out10 vss 40.8286e-18
c508 n11__i28__net8 vss 45.3802e-18
c509 n165__clk100m_b vss 31.9788e-18
c510 n6__i28__i72__x vss 29.3486e-18
c511 n102__net23 vss 30.5779e-18
c512 n437__clk1pt6g vss 47.2189e-18
c513 n6__i28__net8 vss 35.3563e-18
c514 n86__rst_b vss 30.2734e-18
c515 n267__clk100m vss 32.3629e-18
c516 n6__i28__net26 vss 29.739e-18
c517 n138__rst vss 34.726e-18
c518 n163__clk100m_b vss 57.5634e-18
c519 n3__i28__net26 vss 14.5795e-18
c520 n262__clk100m vss 30.8035e-18
c521 n31__en vss 40.8834e-18
c522 n425__clk1pt6g vss 31.5345e-18
c523 n76__net29 vss 44.1262e-18
c524 n6__i28__net7 vss 44.0775e-18
c525 n31__en_b vss 49.5844e-18
c526 n4__i28__i50__net1 vss 39.8895e-18
c527 n4__out9 vss 41.6669e-18
c528 n6__i28__net19 vss 29.1774e-18
c529 n151__clk100m_b vss 31.9788e-18
c530 n93__net23 vss 30.5779e-18
c531 n6__i28__i50__net1 vss 40.5671e-18
c532 n418__clk1pt6g vss 47.2189e-18
c533 n76__rst_b vss 30.2734e-18
c534 n228__clk100m vss 32.3629e-18
c535 n122__rst vss 34.726e-18
c536 n16__i28__net12 vss 26.6274e-18
c537 n15__i28__net8 vss 45.2468e-18
c538 n149__clk100m_b vss 57.5716e-18
c539 n223__clk100m vss 30.8035e-18
c540 n17__i28__net12 vss 25.6426e-18
c541 n28__en vss 40.8834e-18
c542 n406__clk1pt6g vss 31.5345e-18
c543 n9__i28__net8 vss 47.9559e-18
c544 n67__net29 vss 44.1262e-18
c545 n28__en_b vss 49.5844e-18
c546 n3__i28__net12 vss 12.2239e-18
c547 n4__out8 vss 40.4832e-18
c548 n137__clk100m_b vss 31.9788e-18
c549 n13__i28__net12 vss 15.8655e-18
c550 n7__i28__net2 vss 25.2291e-18
c551 n84__net23 vss 30.5779e-18
c552 n399__clk1pt6g vss 47.2189e-18
c553 n66__rst_b vss 30.2734e-18
c554 n6__i28__net2 vss 28.0676e-18
c555 n213__clk100m vss 32.3629e-18
c556 n106__rst vss 34.726e-18
c557 n24__i28__net3 vss 43.4688e-18
c558 n135__clk100m_b vss 57.5789e-18
c559 n208__clk100m vss 30.8035e-18
c560 n27__i28__net3 vss 14.4859e-18
c561 n7__i28__net4 vss 38.6911e-18
c562 n25__en vss 40.8834e-18
c563 n387__clk1pt6g vss 31.5345e-18
c564 n58__net29 vss 44.1262e-18
c565 n6__i28__net4 vss 38.4946e-18
c566 n25__en_b vss 49.5844e-18
c567 n4__out7 vss 40.893e-18
c568 n6__i28__i71__x vss 27.9711e-18
c569 n123__clk100m_b vss 31.9788e-18
c570 n50__i28__net10 vss 33.3242e-18
c571 n75__net23 vss 30.5779e-18
c572 n380__clk1pt6g vss 47.2189e-18
c573 n56__rst_b vss 30.2734e-18
c574 n46__i28__net10 vss 17.8008e-18
c575 n196__clk100m vss 32.3629e-18
c576 n6__i28__net23 vss 29.775e-18
c577 n90__rst vss 34.726e-18
c578 n38__i28__net10 vss 17.9346e-18
c579 n97__clk100m_b vss 57.5288e-18
c580 n3__i28__net23 vss 14.5796e-18
c581 n191__clk100m vss 30.8035e-18
c582 n34__i28__net10 vss 17.9454e-18
c583 n22__en vss 40.8834e-18
c584 n368__clk1pt6g vss 31.5345e-18
c585 n49__net29 vss 44.1262e-18
c586 n26__i28__net10 vss 17.9472e-18
c587 n22__en_b vss 49.5844e-18
c588 n22__i28__net10 vss 17.9547e-18
c589 n4__out6 vss 41.771e-18
c590 n6__i28__net17 vss 28.8066e-18
c591 n14__i28__net10 vss 17.9765e-18
c592 n85__clk100m_b vss 31.9788e-18
c593 n66__net23 vss 30.5779e-18
c594 n361__clk1pt6g vss 47.2189e-18
c595 n12__i28__net10 vss 38.7146e-18
c596 n46__rst_b vss 30.2734e-18
c597 n181__clk100m vss 32.3629e-18
c598 n74__rst vss 34.726e-18
c599 n16__i28__net3 vss 27.7202e-18
c600 n83__clk100m_b vss 57.5783e-18
c601 n106__i28__net14 vss 31.1989e-18
c602 n176__clk100m vss 30.8035e-18
c603 n17__i28__net3 vss 25.8694e-18
c604 n19__en vss 40.8834e-18
c605 n349__clk1pt6g vss 31.5345e-18
c606 n40__net29 vss 44.1262e-18
c607 n102__i28__net14 vss 17.8008e-18
c608 n19__en_b vss 49.5844e-18
c609 n94__i28__net14 vss 17.9346e-18
c610 n3__i28__net3 vss 12.2239e-18
c611 n4__out5 vss 40.6949e-18
c612 n90__i28__net14 vss 17.9454e-18
c613 n71__clk100m_b vss 31.9788e-18
c614 n13__i28__net3 vss 15.8654e-18
c615 n57__net23 vss 30.5779e-18
c616 n339__clk1pt6g vss 47.2189e-18
c617 n82__i28__net14 vss 17.9472e-18
c618 n36__rst_b vss 30.2734e-18
c619 n78__i28__net14 vss 17.9472e-18
c620 n166__clk100m vss 32.3629e-18
c621 n58__rst vss 34.726e-18
c622 n29__i28__net9 vss 29.9914e-18
c623 n70__i28__net14 vss 17.9472e-18
c624 n69__clk100m_b vss 57.5288e-18
c625 n161__clk100m vss 30.8035e-18
c626 n26__i28__net9 vss 14.4688e-18
c627 n16__en vss 40.8834e-18
c628 n325__clk1pt6g vss 31.5345e-18
c629 n31__net29 vss 44.1262e-18
c630 n66__i28__net14 vss 17.9472e-18
c631 n16__en_b vss 49.5844e-18
c632 n58__i28__net14 vss 17.9472e-18
c633 n54__i28__net14 vss 17.9472e-18
c634 n4__out4 vss 40.893e-18
c635 n6__i28__i70__x vss 28.7073e-18
c636 n57__clk100m_b vss 31.9788e-18
c637 n46__i28__net14 vss 17.9472e-18
c638 n46__net23 vss 30.5779e-18
c639 n318__clk1pt6g vss 47.2189e-18
c640 n26__rst_b vss 30.2734e-18
c641 n42__i28__net14 vss 17.9472e-18
c642 n151__clk100m vss 32.3629e-18
c643 n6__i28__net20 vss 29.775e-18
c644 n42__rst vss 34.726e-18
c645 n34__i28__net14 vss 17.9472e-18
c646 n52__clk100m_b vss 57.5288e-18
c647 n3__i28__net20 vss 14.5796e-18
c648 n148__clk100m vss 30.8035e-18
c649 n13__en vss 40.8834e-18
c650 n30__i28__net14 vss 17.9547e-18
c651 n314__clk1pt6g vss 31.5345e-18
c652 n14__net29 vss 44.1262e-18
c653 n13__en_b vss 49.5844e-18
c654 n22__i28__net14 vss 17.9767e-18
c655 n20__i28__net14 vss 35.9674e-18
c656 n6__i28__net15 vss 28.6155e-18
c657 n4__out3 vss 40.5011e-18
c658 n40__clk100m_b vss 31.9788e-18
c659 n14__net23 vss 30.5779e-18
c660 n309__clk1pt6g vss 47.2189e-18
c661 n16__rst_b vss 30.2734e-18
c662 n142__clk100m vss 33.6104e-18
c663 n31__clk100m vss 32.3629e-18
c664 n26__rst vss 34.726e-18
c665 n16__i28__net9 vss 29.2336e-18
c666 n138__clk100m vss 17.8008e-18
c667 n38__clk100m_b vss 57.5288e-18
c668 n28__clk100m vss 30.8035e-18
c669 n17__i28__net9 vss 25.8487e-18
c670 n130__clk100m vss 17.9346e-18
c671 n10__en vss 40.8834e-18
c672 n305__clk1pt6g vss 31.5345e-18
c673 n10__net29 vss 44.1262e-18
c674 n126__clk100m vss 17.9454e-18
c675 n10__en_b vss 49.5844e-18
c676 n118__clk100m vss 17.9472e-18
c677 n3__i28__net9 vss 12.2239e-18
c678 n4__out2 vss 40.8332e-18
c679 n25__clk100m_b vss 31.4737e-18
c680 n114__clk100m vss 17.9472e-18
c681 n13__i28__net9 vss 15.8484e-18
c682 n9__net23 vss 30.5779e-18
c683 n297__clk1pt6g vss 47.2189e-18
c684 n106__clk100m vss 17.9472e-18
c685 n11__rst_b vss 30.2734e-18
c686 n22__clk100m vss 32.3629e-18
c687 n102__clk100m vss 17.9472e-18
c688 n11__net22 vss 29.9914e-18
c689 n16__rst vss 34.726e-18
c690 n24__clk100m_b vss 57.5288e-18
c691 n94__clk100m vss 17.9472e-18
c692 n19__clk100m vss 30.4162e-18
c693 n8__net22 vss 14.5711e-18
c694 n7__en vss 40.8834e-18
c695 n288__clk1pt6g vss 31.5345e-18
c696 n6__net29 vss 44.1262e-18
c697 n90__clk100m vss 17.9472e-18
c698 n7__en_b vss 49.5843e-18
c699 n82__clk100m vss 17.9472e-18
c700 n4__out1 vss 40.893e-18
c701 n78__clk100m vss 17.9472e-18
c702 n6__i28__i69__x vss 28.5219e-18
c703 n17__clk100m_b vss 31.4737e-18
c704 n4__net23 vss 30.6448e-18
c705 n277__clk1pt6g vss 47.2184e-18
c706 n70__clk100m vss 17.9562e-18
c707 n8__rst_b vss 30.2734e-18
c708 n14__clk100m vss 32.7215e-18
c709 n66__clk100m vss 17.9924e-18
c710 n275__clk1pt6g vss 29.5664e-18
c711 n11__rst vss 34.726e-18
c712 n16__clk100m_b vss 50.5527e-18
c713 n58__clk100m vss 18.0356e-18
c714 n272__clk1pt6g vss 14.4898e-18
c715 n11__clk100m vss 30.3614e-18
c716 n4__en vss 41.0701e-18
c717 n266__clk1pt6g vss 30.1009e-18
c718 n2__net29 vss 42.178e-18
c719 n56__clk100m vss 38.6496e-18
c720 n4__en_b vss 48.9606e-18
c721 n6__i28__net1 vss 28.623e-18
c722 n9__clk100m_b vss 31.472e-18
c723 n5__rst_b vss 30.2734e-18
c724 n6__rst vss 34.6976e-18
c725 n215__clk1pt6g vss 68.4169e-18
c726 n108__clk1pt6g vss 41.7659e-18
c727 n6__clk100m vss 30.3646e-18
c728 n261__clk1pt6g vss 32.7197e-18
c729 n1__clk1pt6g vss 36.3775e-18
c730 n2__en vss 34.8749e-18
c731 n210__clk1pt6g vss 17.9676e-18
c732 n253__clk1pt6g vss 32.7005e-18
c733 n103__clk1pt6g vss 18.2105e-18
c734 n2__en_b vss 43.5864e-18
c735 n202__clk1pt6g vss 17.9605e-18
c736 n249__clk1pt6g vss 33.1907e-18
c737 n95__clk1pt6g vss 18.1356e-18
c738 n198__clk1pt6g vss 18.1339e-18
c739 n4__clk100m_b vss 31.2251e-18
c740 n241__clk1pt6g vss 32.7959e-18
c741 n91__clk1pt6g vss 37.3542e-18
c742 n190__clk1pt6g vss 17.9472e-18
c743 n237__clk1pt6g vss 32.7152e-18
c744 n2__rst_b vss 30.4208e-18
c745 n83__clk1pt6g vss 17.9651e-18
c746 n186__clk1pt6g vss 17.9472e-18
c747 n229__clk1pt6g vss 34.4231e-18
c748 n1__rst vss 36.2302e-18
c749 n79__clk1pt6g vss 17.9651e-18
c750 n178__clk1pt6g vss 17.9472e-18
c751 n227__clk1pt6g vss 55.9359e-18
c752 n71__clk1pt6g vss 17.9651e-18
c753 n174__clk1pt6g vss 17.9472e-18
c754 n67__clk1pt6g vss 17.9651e-18
c755 n166__clk1pt6g vss 17.9472e-18
c756 n59__clk1pt6g vss 17.9651e-18
c757 n162__clk1pt6g vss 17.9472e-18
c758 n55__clk1pt6g vss 17.9651e-18
c759 n9__i33__xor2 vss 31.7986e-18
c760 n154__clk1pt6g vss 17.9472e-18
c761 n47__clk1pt6g vss 17.9651e-18
c762 n150__clk1pt6g vss 17.9472e-18
c763 n43__clk1pt6g vss 17.9651e-18
c764 n142__clk1pt6g vss 17.9524e-18
c765 n35__clk1pt6g vss 17.9651e-18
c766 n138__clk1pt6g vss 17.9623e-18
c767 n3__i33__xor2 vss 38.3714e-18
c768 n31__clk1pt6g vss 17.9726e-18
c769 n130__clk1pt6g vss 17.9708e-18
c770 n23__clk1pt6g vss 18.0454e-18
c771 n128__clk1pt6g vss 38.7734e-18
c772 n21__clk1pt6g vss 39.1293e-18
c773 n4__i33__xor1 vss 24.205e-18
c774 n4__net16 vss 25.5491e-18
c775 n7__net17 vss 34.129e-18
c776 n3__net14 vss 27.8556e-18
c777 n6__i33__i57__net1 vss 30.7454e-18
c778 n9__net5 vss 40.5841e-18
c779 n3__net28 vss 29.3457e-18
c780 n3__net25 vss 23.2616e-18
c781 n4__net25 vss 23.0321e-18
c782 n582__clk1pt6g vss 16.4432e-18
c783 n134__net29 vss 38.6886e-18
c784 n7__ext_tx vss 28.9392e-18
c785 n6__ext_tx vss 29.8421e-18
c786 n5__ext_tx vss 38.0153e-18
c787 n4__i29__i161__x vss 32.7666e-18
c788 n3__i40__i42__x vss 30.5749e-18
c789 n153__net23 vss 17.4888e-18
c790 n570__clk1pt6g vss 36.9516e-18
c791 n3__net24 vss 32.1371e-18
c792 n3__i29__net8 vss 54.9847e-18
c793 n4__net24 vss 32.9061e-18
c794 n3__out15 vss 29.4583e-18
c795 n560__clk1pt6g vss 17.2331e-18
c796 n126__net29 vss 38.0405e-18
c797 n3__net21 vss 25.1707e-18
c798 n4__i29__i144__x vss 33.0206e-18
c799 n340__clk100m vss 57.5761e-18
c800 n4__net21 vss 25.1142e-18
c801 n3__i40__i43__x vss 30.5908e-18
c802 n230__clk100m_b vss 33.8451e-18
c803 n48__en vss 39.1382e-18
c804 n144__net23 vss 17.4767e-18
c805 n547__clk1pt6g vss 36.9397e-18
c806 n48__en_b vss 41.9742e-18
c807 n3__i29__net4 vss 54.4456e-18
c808 n11__i28__net6 vss 26.4419e-18
c809 n3__out14 vss 29.4536e-18
c810 n335__clk100m vss 16.5712e-18
c811 n12__i28__net6 vss 28.3889e-18
c812 n538__clk1pt6g vss 17.229e-18
c813 n2__i28__net6 vss 24.0891e-18
c814 n116__net29 vss 38.0405e-18
c815 n4__i33__i0__x vss 35.0937e-18
c816 n125__rst_b vss 40.4663e-18
c817 n4__i29__i143__x vss 32.9628e-18
c818 n3__i28__net6 vss 28.7425e-18
c819 n327__clk100m vss 60.0948e-18
c820 n205__rst vss 22.2048e-18
c821 n8__i28__net11 vss 39.6969e-18
c822 n3__i40__i44__x vss 30.5908e-18
c823 n219__clk100m_b vss 33.8389e-18
c824 n217__clk100m_b vss 17.7768e-18
c825 n9__i28__net11 vss 25.7846e-18
c826 n45__en vss 40.7826e-18
c827 n66__net22 vss 23.7254e-18
c828 n135__net23 vss 17.4767e-18
c829 n521__clk1pt6g vss 36.9367e-18
c830 n3__i33__i0__net1 vss 38.8847e-18
c831 n45__en_b vss 42.0019e-18
c832 n67__net22 vss 23.666e-18
c833 n3__i29__net3 vss 54.8449e-18
c834 n3__i28__i51__x vss 27.2756e-18
c835 n3__out13 vss 29.4536e-18
c836 n320__clk100m vss 17.2105e-18
c837 n4__i28__i51__x vss 28.8036e-18
c838 n2__i28__i52__x vss 25.1074e-18
c839 n512__clk1pt6g vss 17.229e-18
c840 n107__net29 vss 38.0378e-18
c841 n4__i33__i16__x vss 34.8902e-18
c842 n115__rst_b vss 42.3618e-18
c843 n3__i28__i52__x vss 27.9136e-18
c844 n4__i29__i142__x vss 32.211e-18
c845 n312__clk100m vss 60.0948e-18
c846 n19__i28__net13 vss 37.9306e-18
c847 n189__rst vss 22.4616e-18
c848 n3__i40__i45__x vss 30.5908e-18
c849 n205__clk100m_b vss 33.8389e-18
c850 n20__i28__net13 vss 25.7245e-18
c851 n203__clk100m_b vss 17.7474e-18
c852 n502__clk1pt6g vss 23.6606e-18
c853 n42__en vss 40.7826e-18
c854 n126__net23 vss 17.4767e-18
c855 n497__clk1pt6g vss 36.9367e-18
c856 n3__i33__i16__net1 vss 38.8736e-18
c857 n503__clk1pt6g vss 21.5324e-18
c858 n42__en_b vss 42.0019e-18
c859 n3__i29__net2 vss 54.4795e-18
c860 n3__i28__net5 vss 30.9441e-18
c861 n3__out12 vss 29.4536e-18
c862 n4__i28__net5 vss 28.0258e-18
c863 n305__clk100m vss 17.2049e-18
c864 n8__i28__net7 vss 25.1133e-18
c865 n490__clk1pt6g vss 17.229e-18
c866 n100__net29 vss 38.0405e-18
c867 n4__i33__i18__x vss 34.8902e-18
c868 n9__i28__net7 vss 28.7162e-18
c869 n105__rst_b vss 42.3615e-18
c870 n4__i29__i141__x vss 32.2607e-18
c871 n296__clk100m vss 60.0948e-18
c872 n173__rst vss 22.4511e-18
c873 n10__i28__net13 vss 25.6616e-18
c874 n3__i40__i46__x vss 30.5908e-18
c875 n191__clk100m_b vss 33.8389e-18
c876 n189__clk100m_b vss 17.7474e-18
c877 n54__net22 vss 21.6105e-18
c878 n9__i28__net13 vss 24.8169e-18
c879 n39__en vss 40.7826e-18
c880 n117__net23 vss 17.4767e-18
c881 n471__clk1pt6g vss 36.9397e-18
c882 n3__i33__i18__net1 vss 38.8736e-18
c883 n55__net22 vss 22.6078e-18
c884 n39__en_b vss 42.0019e-18
c885 n3__i29__net1 vss 54.5466e-18
c886 n5__i28__net13 vss 22.1284e-18
c887 n3__out11 vss 29.4536e-18
c888 n2__i28__i53__x vss 26.721e-18
c889 n289__clk100m vss 17.2049e-18
c890 n6__i28__net13 vss 28.4555e-18
c891 n464__clk1pt6g vss 17.229e-18
c892 n91__net29 vss 38.0405e-18
c893 n3__i28__i53__x vss 28.0797e-18
c894 n4__i33__i17__x vss 34.8902e-18
c895 n95__rst_b vss 42.3615e-18
c896 n4__i29__i140__x vss 32.0744e-18
c897 n281__clk100m vss 60.0948e-18
c898 n157__rst vss 22.4511e-18
c899 n8__i28__net26 vss 39.1008e-18
c900 n3__i40__i47__x vss 30.5908e-18
c901 n175__clk100m_b vss 33.8389e-18
c902 n452__clk1pt6g vss 22.5187e-18
c903 n173__clk100m_b vss 17.7474e-18
c904 n9__i28__net26 vss 25.847e-18
c905 n36__en vss 40.7826e-18
c906 n108__net23 vss 17.4767e-18
c907 n447__clk1pt6g vss 36.9367e-18
c908 n453__clk1pt6g vss 20.2119e-18
c909 n3__i33__i17__net1 vss 38.8736e-18
c910 n36__en_b vss 42.0019e-18
c911 n3__i29__net5 vss 54.0551e-18
c912 n3__i28__i72__x vss 27.0051e-18
c913 n3__out10 vss 29.4536e-18
c914 n13__i28__net8 vss 20.5584e-18
c915 n274__clk100m vss 17.2049e-18
c916 n4__i28__i72__x vss 28.833e-18
c917 n440__clk1pt6g vss 17.229e-18
c918 n82__net29 vss 38.0378e-18
c919 n4__i28__net8 vss 18.5043e-18
c920 n4__i33__i22__x vss 34.8902e-18
c921 n85__rst_b vss 42.3615e-18
c922 n4__i29__i139__x vss 33.2774e-18
c923 n266__clk100m vss 60.0948e-18
c924 n19__i28__net12 vss 37.8679e-18
c925 n141__rst vss 22.4511e-18
c926 n3__i40__i48__x vss 30.5908e-18
c927 n5__i28__net7 vss 31.6909e-18
c928 n161__clk100m_b vss 33.8389e-18
c929 n20__i28__net12 vss 25.3138e-18
c930 n159__clk100m_b vss 17.7474e-18
c931 n33__en vss 40.7819e-18
c932 n99__net23 vss 17.4767e-18
c933 n428__clk1pt6g vss 36.9367e-18
c934 n4__i28__net7 vss 33.9525e-18
c935 n3__i33__i22__net1 vss 38.8736e-18
c936 n33__en_b vss 41.6061e-18
c937 n3__i29__net11 vss 54.9788e-18
c938 n3__i28__net19 vss 30.7195e-18
c939 n3__out9 vss 29.4536e-18
c940 n4__i28__net19 vss 27.5987e-18
c941 n235__clk100m vss 17.2049e-18
c942 n421__clk1pt6g vss 17.229e-18
c943 n10__i28__net8 vss 42.8608e-18
c944 n73__net29 vss 38.0405e-18
c945 n4__i33__i19__x vss 34.8902e-18
c946 n75__rst_b vss 42.3615e-18
c947 n4__i29__i138__x vss 32.9525e-18
c948 n227__clk100m vss 60.0948e-18
c949 n125__rst vss 22.4511e-18
c950 n10__i28__net12 vss 25.6259e-18
c951 n3__i40__i49__x vss 30.5908e-18
c952 n147__clk100m_b vss 33.8389e-18
c953 n145__clk100m_b vss 17.7474e-18
c954 n9__i28__net12 vss 24.7235e-18
c955 n30__en vss 40.7819e-18
c956 n90__net23 vss 17.4767e-18
c957 n3__i28__i50__net1 vss 25.4836e-18
c958 n409__clk1pt6g vss 36.9397e-18
c959 n3__i33__i19__net1 vss 38.8736e-18
c960 n30__en_b vss 42.0019e-18
c961 n3__i29__net31 vss 53.5313e-18
c962 n5__i28__net12 vss 22.4513e-18
c963 n3__out8 vss 29.4536e-18
c964 n220__clk100m vss 17.2049e-18
c965 n6__i28__net12 vss 29.2127e-18
c966 n3__i28__net2 vss 22.8623e-18
c967 n402__clk1pt6g vss 17.229e-18
c968 n64__net29 vss 38.0405e-18
c969 n4__i33__i21__x vss 34.8902e-18
c970 n65__rst_b vss 42.3615e-18
c971 n4__i28__net2 vss 24.462e-18
c972 n4__i29__i137__x vss 32.6e-18
c973 n212__clk100m vss 60.0948e-18
c974 n109__rst vss 22.4511e-18
c975 n8__i28__net23 vss 39.1445e-18
c976 n3__i40__i50__x vss 30.5908e-18
c977 n133__clk100m_b vss 33.8389e-18
c978 n131__clk100m_b vss 17.7474e-18
c979 n9__i28__net23 vss 26.4769e-18
c980 n3__i28__net4 vss 35.5646e-18
c981 n27__en vss 40.7826e-18
c982 n81__net23 vss 17.4767e-18
c983 n390__clk1pt6g vss 36.9367e-18
c984 n3__i33__i21__net1 vss 38.8736e-18
c985 n4__i28__net4 vss 30.1858e-18
c986 n27__en_b vss 42.0019e-18
c987 n3__i29__net15 vss 53.6494e-18
c988 n3__i28__i71__x vss 27.6189e-18
c989 n3__out7 vss 29.4536e-18
c990 n4__i28__i71__x vss 29.2259e-18
c991 n205__clk100m vss 17.2049e-18
c992 n3__i28__net10 vss 28.8031e-18
c993 n383__clk1pt6g vss 17.229e-18
c994 n55__net29 vss 38.0378e-18
c995 n4__i33__i20__x vss 34.8902e-18
c996 n55__rst_b vss 42.3615e-18
c997 n44__i28__net10 vss 9.21516e-18
c998 n4__i29__i136__x vss 32.8188e-18
c999 n195__clk100m vss 60.0948e-18
c1000 n19__i28__net3 vss 37.895e-18
c1001 n93__rst vss 22.4511e-18
c1002 n40__i28__net10 vss 9.27685e-18
c1003 n3__i40__i51__x vss 30.5908e-18
c1004 n95__clk100m_b vss 33.8389e-18
c1005 n20__i28__net3 vss 25.1602e-18
c1006 n93__clk100m_b vss 17.7474e-18
c1007 n32__i28__net10 vss 9.27789e-18
c1008 n24__en vss 40.7826e-18
c1009 n72__net23 vss 17.4767e-18
c1010 n371__clk1pt6g vss 36.9367e-18
c1011 n3__i33__i20__net1 vss 38.8736e-18
c1012 n28__i28__net10 vss 9.26959e-18
c1013 n24__en_b vss 42.0019e-18
c1014 n3__i29__net22 vss 54.7826e-18
c1015 n3__i28__net17 vss 30.8079e-18
c1016 n20__i28__net10 vss 9.27685e-18
c1017 n3__out6 vss 29.4536e-18
c1018 n4__i28__net17 vss 27.2977e-18
c1019 n16__i28__net10 vss 9.27092e-18
c1020 n188__clk100m vss 17.2049e-18
c1021 n364__clk1pt6g vss 17.229e-18
c1022 n46__net29 vss 38.0405e-18
c1023 n10__i28__net10 vss 25.6429e-18
c1024 n4__i33__i30__x vss 34.8902e-18
c1025 n45__rst_b vss 42.3615e-18
c1026 n4__i29__i135__x vss 31.6505e-18
c1027 n180__clk100m vss 60.0948e-18
c1028 n77__rst vss 22.4511e-18
c1029 n10__i28__net3 vss 25.0812e-18
c1030 n3__i40__i52__x vss 30.5908e-18
c1031 n81__clk100m_b vss 33.8389e-18
c1032 n3__i28__net14 vss 27.3896e-18
c1033 n79__clk100m_b vss 17.7474e-18
c1034 n9__i28__net3 vss 25.4641e-18
c1035 n21__en vss 40.7826e-18
c1036 n63__net23 vss 17.4767e-18
c1037 n352__clk1pt6g vss 36.9397e-18
c1038 n100__i28__net14 vss 9.21516e-18
c1039 n3__i33__i30__net1 vss 38.8736e-18
c1040 n21__en_b vss 42.0019e-18
c1041 n3__i29__net30 vss 54.9363e-18
c1042 n96__i28__net14 vss 9.27685e-18
c1043 n5__i28__net3 vss 22.3694e-18
c1044 n3__out5 vss 29.4536e-18
c1045 n88__i28__net14 vss 9.26959e-18
c1046 n173__clk100m vss 17.2049e-18
c1047 n6__i28__net3 vss 29.2774e-18
c1048 n344__clk1pt6g vss 17.229e-18
c1049 n35__net29 vss 38.0405e-18
c1050 n84__i28__net14 vss 9.26959e-18
c1051 n4__i33__i23__x vss 34.8902e-18
c1052 n35__rst_b vss 42.3615e-18
c1053 n4__i29__i134__x vss 32.8905e-18
c1054 n76__i28__net14 vss 9.26959e-18
c1055 n165__clk100m vss 60.0948e-18
c1056 n61__rst vss 22.4511e-18
c1057 n8__i28__net20 vss 38.6297e-18
c1058 n3__i40__i53__x vss 30.5908e-18
c1059 n72__i28__net14 vss 9.26959e-18
c1060 n67__clk100m_b vss 33.8389e-18
c1061 n65__clk100m_b vss 17.7474e-18
c1062 n9__i28__net20 vss 26.3198e-18
c1063 n18__en vss 40.7826e-18
c1064 n54__net23 vss 17.4767e-18
c1065 n329__clk1pt6g vss 36.9367e-18
c1066 n64__i28__net14 vss 9.26959e-18
c1067 n3__i33__i23__net1 vss 38.8736e-18
c1068 n18__en_b vss 42.0019e-18
c1069 n3__i29__net17 vss 54.9829e-18
c1070 n60__i28__net14 vss 9.26959e-18
c1071 n3__i28__i70__x vss 28.6649e-18
c1072 n52__i28__net14 vss 9.26959e-18
c1073 n3__out4 vss 29.4536e-18
c1074 n4__i28__i70__x vss 29.1898e-18
c1075 n158__clk100m vss 17.2049e-18
c1076 n48__i28__net14 vss 9.26959e-18
c1077 n321__clk1pt6g vss 17.229e-18
c1078 n28__net29 vss 38.0378e-18
c1079 n4__i33__i25__x vss 34.8902e-18
c1080 n25__rst_b vss 42.3615e-18
c1081 n40__i28__net14 vss 9.28377e-18
c1082 n4__i29__i133__x vss 32.8956e-18
c1083 n150__clk100m vss 60.0948e-18
c1084 n19__i28__net9 vss 37.8305e-18
c1085 n45__rst vss 22.4511e-18
c1086 n36__i28__net14 vss 9.26959e-18
c1087 n3__i40__i54__x vss 30.5908e-18
c1088 n50__clk100m_b vss 33.8389e-18
c1089 n20__i28__net9 vss 24.8669e-18
c1090 n48__clk100m_b vss 17.7474e-18
c1091 n15__en vss 40.7826e-18
c1092 n28__i28__net14 vss 9.29902e-18
c1093 n17__net23 vss 17.4767e-18
c1094 n317__clk1pt6g vss 36.9367e-18
c1095 n3__i33__i25__net1 vss 38.8736e-18
c1096 n15__en_b vss 42.0019e-18
c1097 n24__i28__net14 vss 9.27109e-18
c1098 n3__i29__net10 vss 54.9508e-18
c1099 n3__i28__net15 vss 32.0174e-18
c1100 n18__i28__net14 vss 26.8736e-18
c1101 n4__i28__net15 vss 24.4294e-18
c1102 n3__out3 vss 29.4536e-18
c1103 n145__clk100m vss 17.2049e-18
c1104 n312__clk1pt6g vss 17.229e-18
c1105 n11__net29 vss 38.0405e-18
c1106 n4__i33__i24__x vss 34.7695e-18
c1107 n15__rst_b vss 42.3615e-18
c1108 n39__clk100m vss 23.8445e-18
c1109 n4__i29__i132__x vss 32.7343e-18
c1110 n30__clk100m vss 60.0948e-18
c1111 n29__rst vss 22.4511e-18
c1112 n10__i28__net9 vss 25.0038e-18
c1113 n136__clk100m vss 9.49899e-18
c1114 n3__i40__i55__x vss 30.5908e-18
c1115 n36__clk100m_b vss 33.8389e-18
c1116 n34__clk100m_b vss 17.7474e-18
c1117 n9__i28__net9 vss 25.6425e-18
c1118 n132__clk100m vss 9.53861e-18
c1119 n12__en vss 40.7826e-18
c1120 n12__net23 vss 17.4767e-18
c1121 n308__clk1pt6g vss 36.9397e-18
c1122 n3__i33__i24__net1 vss 38.8058e-18
c1123 n124__clk100m vss 9.55342e-18
c1124 n12__en_b vss 42.0019e-18
c1125 n3__i29__net20 vss 54.9262e-18
c1126 n120__clk100m vss 9.5393e-18
c1127 n5__i28__net9 vss 21.3553e-18
c1128 n3__out2 vss 29.4536e-18
c1129 n25__clk100m vss 17.4686e-18
c1130 n112__clk100m vss 9.59978e-18
c1131 n6__i28__net9 vss 29.5238e-18
c1132 n300__clk1pt6g vss 17.229e-18
c1133 n7__net29 vss 38.0405e-18
c1134 n4__i33__i29__x vss 34.4463e-18
c1135 n108__clk100m vss 9.59978e-18
c1136 n10__rst_b vss 42.3615e-18
c1137 n4__i29__i131__x vss 32.688e-18
c1138 n21__clk100m vss 60.0948e-18
c1139 n100__clk100m vss 9.59978e-18
c1140 n292__clk1pt6g vss 38.102e-18
c1141 n19__rst vss 22.4511e-18
c1142 n3__i40__i56__x vss 30.5908e-18
c1143 n22__clk100m_b vss 33.8385e-18
c1144 n96__clk100m vss 9.55342e-18
c1145 n20__clk100m_b vss 17.1404e-18
c1146 n293__clk1pt6g vss 24.3889e-18
c1147 n9__en vss 40.7826e-18
c1148 n7__net23 vss 17.4767e-18
c1149 n291__clk1pt6g vss 36.9367e-18
c1150 n88__clk100m vss 9.59978e-18
c1151 n3__i33__i29__net1 vss 38.5727e-18
c1152 n9__en_b vss 42.0018e-18
c1153 n3__i29__net27 vss 54.926e-18
c1154 n84__clk100m vss 9.60123e-18
c1155 n3__i28__i69__x vss 29.1587e-18
c1156 n3__out1 vss 29.4536e-18
c1157 n76__clk100m vss 9.58605e-18
c1158 n4__i28__i69__x vss 29.1963e-18
c1159 n17__clk100m vss 17.4627e-18
c1160 n280__clk1pt6g vss 17.2303e-18
c1161 n3__net29 vss 38.0405e-18
c1162 n72__clk100m vss 9.2425e-18
c1163 n4__i33__i26__x vss 34.4463e-18
c1164 n7__rst_b vss 42.3594e-18
c1165 n4__i29__i130__x vss 32.8109e-18
c1166 n13__clk100m vss 60.0863e-18
c1167 n64__clk100m vss 9.25279e-18
c1168 n14__rst vss 22.4511e-18
c1169 n3__i40__i57__x vss 30.5805e-18
c1170 n14__clk100m_b vss 32.464e-18
c1171 n60__clk100m vss 9.26381e-18
c1172 n2__net22 vss 24.3959e-18
c1173 n12__clk100m_b vss 17.1404e-18
c1174 n6__en vss 40.2928e-18
c1175 n2__net23 vss 17.5758e-18
c1176 n269__clk1pt6g vss 41.8746e-18
c1177 n54__clk100m vss 29.1407e-18
c1178 n3__i33__i26__net1 vss 38.4795e-18
c1179 n6__en_b vss 42.0873e-18
c1180 n3__net18 vss 32.8986e-18
c1181 n3__i28__net1 vss 31.7633e-18
c1182 n4__i28__net1 vss 23.5481e-18
c1183 n9__clk100m vss 17.469e-18
c1184 n4__i33__i28__x vss 35.0314e-18
c1185 n4__rst_b vss 42.3594e-18
c1186 n9__rst vss 22.4511e-18
c1187 n217__clk1pt6g vss 41.1132e-18
c1188 n110__clk1pt6g vss 28.5573e-18
c1189 n7__clk100m_b vss 17.6081e-18
c1190 n259__clk1pt6g vss 16.9116e-18
c1191 n3__clk1pt6g vss 25.5515e-18
c1192 n3__en vss 36.2916e-18
c1193 n208__clk1pt6g vss 9.2922e-18
c1194 n3__i33__i28__net1 vss 39.1365e-18
c1195 n255__clk1pt6g vss 16.6139e-18
c1196 n101__clk1pt6g vss 9.36741e-18
c1197 n3__en_b vss 41.6255e-18
c1198 n204__clk1pt6g vss 9.25448e-18
c1199 n247__clk1pt6g vss 16.6067e-18
c1200 n97__clk1pt6g vss 9.25497e-18
c1201 n196__clk1pt6g vss 9.91384e-18
c1202 n4__clk100m vss 17.8417e-18
c1203 n243__clk1pt6g vss 16.6119e-18
c1204 n89__clk1pt6g vss 9.23174e-18
c1205 n192__clk1pt6g vss 9.402e-18
c1206 n4__i33__i27__x vss 33.6897e-18
c1207 n235__clk1pt6g vss 16.6215e-18
c1208 n1__rst_b vss 42.4057e-18
c1209 n85__clk1pt6g vss 9.23292e-18
c1210 n184__clk1pt6g vss 9.25242e-18
c1211 n231__clk1pt6g vss 18.0689e-18
c1212 n4__rst vss 24.0163e-18
c1213 n77__clk1pt6g vss 9.23292e-18
c1214 n180__clk1pt6g vss 9.23292e-18
c1215 n224__clk1pt6g vss 37.0148e-18
c1216 n2__clk100m_b vss 17.9854e-18
c1217 n73__clk1pt6g vss 9.23292e-18
c1218 n172__clk1pt6g vss 9.23292e-18
c1219 n3__i33__i27__net1 vss 38.1719e-18
c1220 n65__clk1pt6g vss 9.23292e-18
c1221 n168__clk1pt6g vss 9.23292e-18
c1222 n61__clk1pt6g vss 9.23292e-18
c1223 n160__clk1pt6g vss 9.23292e-18
c1224 n53__clk1pt6g vss 9.23292e-18
c1225 n5__i33__i56__net1 vss 28.0739e-18
c1226 n156__clk1pt6g vss 9.23292e-18
c1227 n49__clk1pt6g vss 9.23292e-18
c1228 n7__i33__xor2 vss 24.2692e-18
c1229 n148__clk1pt6g vss 9.23292e-18
c1230 n41__clk1pt6g vss 9.23292e-18
c1231 n144__clk1pt6g vss 9.23815e-18
c1232 n37__clk1pt6g vss 9.23292e-18
c1233 n136__clk1pt6g vss 9.24778e-18
c1234 n2__i33__xor2 vss 15.293e-18
c1235 n29__clk1pt6g vss 9.24018e-18
c1236 n132__clk1pt6g vss 9.20395e-18
c1237 n25__clk1pt6g vss 9.25772e-18
c1238 n125__clk1pt6g vss 26.1102e-18
c1239 n18__clk1pt6g vss 28.8254e-18
c1240 n3__net16 vss 21.4257e-18
c1241 n8__net17 vss 15.3101e-18
c1242 n4__net14 vss 19.353e-18
c1243 n6__net17 vss 24.274e-18
c1244 n7__net5 vss 19.6256e-18
c1245 n5__net5 vss 24.0231e-18
c1246 n4__i33__i58__net1 vss 27.1324e-18
c1247 n8__net25 vss 237.436e-18
c1248 n157__net23 vss 30.237e-18
c1249 n581__clk1pt6g vss 27.9244e-18
c1250 n583__clk1pt6g vss 26.9839e-18
c1251 n580__clk1pt6g vss 27.3064e-18
c1252 n135__net29 vss 22.7928e-18
c1253 n3__i29__i161__x vss 38.0399e-18
c1254 n2__i40__i42__x vss 59.4065e-18
c1255 n128__net29 vss 28.361e-18
c1256 n569__clk1pt6g vss 23.8902e-18
c1257 n568__clk1pt6g vss 97.4168e-18
c1258 n152__net23 vss 74.0842e-18
c1259 n154__net23 vss 25.401e-18
c1260 n2__i29__net8 vss 103.605e-18
c1261 n1__out15 vss 46.0407e-18
c1262 n6__net24 vss 85.5342e-18
c1263 n148__net23 vss 32.2058e-18
c1264 n559__clk1pt6g vss 29.6206e-18
c1265 n561__clk1pt6g vss 27.4367e-18
c1266 n558__clk1pt6g vss 27.5942e-18
c1267 n127__net29 vss 23.0712e-18
c1268 n342__clk100m vss 23.2534e-18
c1269 n3__i29__i144__x vss 39.0177e-18
c1270 n2__i40__i43__x vss 59.446e-18
c1271 n6__net21 vss 55.5236e-18
c1272 n231__clk100m_b vss 388.706e-18
c1273 n120__net29 vss 27.7744e-18
c1274 n546__clk1pt6g vss 23.7407e-18
c1275 n47__en vss 240.097e-18
c1276 n545__clk1pt6g vss 31.5314e-18
c1277 n143__net23 vss 74.0953e-18
c1278 n145__net23 vss 26.0194e-18
c1279 n9__i28__net6 vss 32.0548e-18
c1280 n47__en_b vss 194.883e-18
c1281 n2__i29__net4 vss 107.158e-18
c1282 n1__out14 vss 45.5282e-18
c1283 n224__clk100m_b vss 31.797e-18
c1284 n334__clk100m vss 28.5092e-18
c1285 n336__clk100m vss 26.0218e-18
c1286 n13__i28__net6 vss 88.0365e-18
c1287 n139__net23 vss 32.1898e-18
c1288 n537__clk1pt6g vss 29.6206e-18
c1289 n539__clk1pt6g vss 24.8628e-18
c1290 n536__clk1pt6g vss 26.5312e-18
c1291 n117__net29 vss 23.0712e-18
c1292 n127__rst_b vss 114.973e-18
c1293 n3__i33__i0__x vss 40.8933e-18
c1294 n329__clk100m vss 23.2361e-18
c1295 n3__i29__i143__x vss 39.2914e-18
c1296 n206__rst vss 167.91e-18
c1297 n204__rst vss 7.94974e-18
c1298 n2__i40__i44__x vss 59.2627e-18
c1299 n220__clk100m_b vss 371.741e-18
c1300 n530__clk1pt6g vss 75.2961e-18
c1301 n64__net22 vss 79.3402e-18
c1302 n324__clk100m vss 31.7017e-18
c1303 n216__clk100m_b vss 131.474e-18
c1304 n218__clk100m_b vss 25.7724e-18
c1305 n111__net29 vss 28.8191e-18
c1306 n520__clk1pt6g vss 23.7407e-18
c1307 n24__i28__net13 vss 23.439e-18
c1308 n44__en vss 438.433e-18
c1309 n28__i28__net13 vss 77.0374e-18
c1310 n11__i28__net11 vss 72.268e-18
c1311 n519__clk1pt6g vss 31.5314e-18
c1312 n134__net23 vss 74.0838e-18
c1313 n136__net23 vss 24.2237e-18
c1314 n2__i33__i0__net1 vss 38.9073e-18
c1315 n524__clk1pt6g vss 26.8586e-18
c1316 n44__en_b vss 305.928e-18
c1317 n2__i29__net3 vss 107.071e-18
c1318 n1__out13 vss 45.4509e-18
c1319 n210__clk100m_b vss 31.9215e-18
c1320 n319__clk100m vss 29.2321e-18
c1321 n321__clk100m vss 25.167e-18
c1322 n5__i28__i51__x vss 61.8967e-18
c1323 n130__net23 vss 32.1898e-18
c1324 n511__clk1pt6g vss 29.6206e-18
c1325 n513__clk1pt6g vss 23.8767e-18
c1326 n510__clk1pt6g vss 27.7844e-18
c1327 n108__net29 vss 23.0712e-18
c1328 n117__rst_b vss 29.2704e-18
c1329 n3__i33__i16__x vss 40.8127e-18
c1330 n314__clk100m vss 23.2361e-18
c1331 n3__i29__i142__x vss 39.2882e-18
c1332 n190__rst vss 285.407e-18
c1333 n188__rst vss 7.94946e-18
c1334 n2__i40__i45__x vss 59.5566e-18
c1335 n63__net22 vss 77.0922e-18
c1336 n500__clk1pt6g vss 71.0791e-18
c1337 n206__clk100m_b vss 371.741e-18
c1338 n309__clk100m vss 31.7179e-18
c1339 n202__clk100m_b vss 131.46e-18
c1340 n204__clk100m_b vss 25.7659e-18
c1341 n5__i28__net11 vss 76.5255e-18
c1342 n22__i28__net13 vss 81.2926e-18
c1343 n102__net29 vss 26.0355e-18
c1344 n496__clk1pt6g vss 23.7407e-18
c1345 n41__en vss 438.429e-18
c1346 n495__clk1pt6g vss 31.5314e-18
c1347 n125__net23 vss 74.0838e-18
c1348 n127__net23 vss 25.6611e-18
c1349 n57__net22 vss 30.3306e-18
c1350 n2__i33__i16__net1 vss 38.8682e-18
c1351 n41__en_b vss 305.948e-18
c1352 n2__i29__net2 vss 107.036e-18
c1353 n1__out12 vss 45.4394e-18
c1354 n7__i28__net7 vss 42.47e-18
c1355 n5__i28__net5 vss 52.1616e-18
c1356 n196__clk100m_b vss 31.8646e-18
c1357 n304__clk100m vss 29.2321e-18
c1358 n306__clk100m vss 25.167e-18
c1359 n121__net23 vss 32.1898e-18
c1360 n489__clk1pt6g vss 29.6206e-18
c1361 n491__clk1pt6g vss 23.7778e-18
c1362 n488__clk1pt6g vss 28.0211e-18
c1363 n101__net29 vss 23.0712e-18
c1364 n107__rst_b vss 114.537e-18
c1365 n3__i33__i18__x vss 40.8127e-18
c1366 n298__clk100m vss 23.2361e-18
c1367 n3__i29__i141__x vss 39.2753e-18
c1368 n174__rst vss 285.383e-18
c1369 n172__rst vss 7.94946e-18
c1370 n2__i40__i46__x vss 59.5335e-18
c1371 n480__clk1pt6g vss 76.6745e-18
c1372 n52__net22 vss 78.7849e-18
c1373 n192__clk100m_b vss 371.741e-18
c1374 n293__clk100m vss 31.7694e-18
c1375 n188__clk100m_b vss 131.46e-18
c1376 n190__clk100m_b vss 25.7659e-18
c1377 n93__net29 vss 27.4201e-18
c1378 n470__clk1pt6g vss 23.7407e-18
c1379 n38__en vss 438.429e-18
c1380 n469__clk1pt6g vss 31.5314e-18
c1381 n116__net23 vss 74.0838e-18
c1382 n118__net23 vss 25.9874e-18
c1383 n474__clk1pt6g vss 27.5087e-18
c1384 n2__i33__i18__net1 vss 38.8682e-18
c1385 n38__en_b vss 306.406e-18
c1386 n2__i29__net1 vss 107.036e-18
c1387 n1__out11 vss 45.5277e-18
c1388 n180__clk100m_b vss 31.8646e-18
c1389 n288__clk100m vss 29.226e-18
c1390 n290__clk100m vss 25.167e-18
c1391 n7__i28__net13 vss 88.1903e-18
c1392 n112__net23 vss 32.1898e-18
c1393 n463__clk1pt6g vss 29.6206e-18
c1394 n465__clk1pt6g vss 24.4376e-18
c1395 n462__clk1pt6g vss 27.6497e-18
c1396 n92__net29 vss 23.0712e-18
c1397 n97__rst_b vss 29.2704e-18
c1398 n3__i33__i17__x vss 40.8127e-18
c1399 n283__clk100m vss 23.2361e-18
c1400 n3__i29__i140__x vss 39.26e-18
c1401 n158__rst vss 285.383e-18
c1402 n51__net22 vss 76.064e-18
c1403 n450__clk1pt6g vss 70.0458e-18
c1404 n156__rst vss 7.94946e-18
c1405 n2__i40__i47__x vss 59.3256e-18
c1406 n176__clk100m_b vss 371.741e-18
c1407 n278__clk100m vss 31.7694e-18
c1408 n172__clk100m_b vss 131.454e-18
c1409 n174__clk100m_b vss 25.7659e-18
c1410 n24__i28__net12 vss 25.0369e-18
c1411 n84__net29 vss 28.6907e-18
c1412 n446__clk1pt6g vss 23.7407e-18
c1413 n35__en vss 438.429e-18
c1414 n28__i28__net12 vss 76.876e-18
c1415 n11__i28__net26 vss 72.3511e-18
c1416 n45__net22 vss 24.8846e-18
c1417 n445__clk1pt6g vss 31.5314e-18
c1418 n107__net23 vss 74.0953e-18
c1419 n109__net23 vss 25.992e-18
c1420 n2__i33__i17__net1 vss 70.9159e-18
c1421 n35__en_b vss 306.719e-18
c1422 n2__i29__net5 vss 107.036e-18
c1423 n1__out10 vss 45.3746e-18
c1424 n12__i28__net8 vss 76.9821e-18
c1425 n166__clk100m_b vss 31.9215e-18
c1426 n273__clk100m vss 29.226e-18
c1427 n275__clk100m vss 25.167e-18
c1428 n5__i28__i72__x vss 61.5723e-18
c1429 n103__net23 vss 32.1898e-18
c1430 n439__clk1pt6g vss 29.6206e-18
c1431 n441__clk1pt6g vss 32.589e-18
c1432 n438__clk1pt6g vss 28.0458e-18
c1433 n83__net29 vss 23.0712e-18
c1434 n87__rst_b vss 114.537e-18
c1435 n3__i33__i22__x vss 40.8127e-18
c1436 n268__clk100m vss 23.2361e-18
c1437 n3__i29__i139__x vss 39.2145e-18
c1438 n142__rst vss 285.383e-18
c1439 n140__rst vss 7.94946e-18
c1440 n2__i28__net7 vss 19.0384e-18
c1441 n2__i40__i48__x vss 59.1842e-18
c1442 n162__clk100m_b vss 371.741e-18
c1443 n263__clk100m vss 31.7179e-18
c1444 n158__clk100m_b vss 131.454e-18
c1445 n160__clk100m_b vss 25.7659e-18
c1446 n5__i28__net26 vss 76.7387e-18
c1447 n22__i28__net12 vss 81.0177e-18
c1448 n75__net29 vss 26.0911e-18
c1449 n427__clk1pt6g vss 23.7407e-18
c1450 n32__en vss 438.429e-18
c1451 n426__clk1pt6g vss 31.5314e-18
c1452 n98__net23 vss 74.0953e-18
c1453 n100__net23 vss 32.0996e-18
c1454 n2__i33__i22__net1 vss 38.8522e-18
c1455 n32__en_b vss 306.719e-18
c1456 n2__i29__net11 vss 107.422e-18
c1457 n1__out9 vss 45.4289e-18
c1458 n5__i28__net19 vss 52.3507e-18
c1459 n5__i28__i50__net1 vss 52.2563e-18
c1460 n152__clk100m_b vss 31.9215e-18
c1461 n234__clk100m vss 29.226e-18
c1462 n236__clk100m vss 25.167e-18
c1463 n94__net23 vss 32.1898e-18
c1464 n420__clk1pt6g vss 29.6206e-18
c1465 n422__clk1pt6g vss 32.5508e-18
c1466 n419__clk1pt6g vss 28.4625e-18
c1467 n74__net29 vss 23.0712e-18
c1468 n77__rst_b vss 29.2704e-18
c1469 n3__i33__i19__x vss 40.8127e-18
c1470 n229__clk100m vss 23.2361e-18
c1471 n3__i29__i138__x vss 39.2125e-18
c1472 n126__rst vss 285.383e-18
c1473 n124__rst vss 7.94946e-18
c1474 n2__i40__i49__x vss 59.4459e-18
c1475 n148__clk100m_b vss 371.741e-18
c1476 n2__i28__i50__net1 vss 25.8298e-18
c1477 n224__clk100m vss 31.7179e-18
c1478 n144__clk100m_b vss 131.454e-18
c1479 n146__clk100m_b vss 25.7659e-18
c1480 n66__net29 vss 27.307e-18
c1481 n408__clk1pt6g vss 23.7407e-18
c1482 n29__en vss 438.649e-18
c1483 n407__clk1pt6g vss 31.5314e-18
c1484 n89__net23 vss 74.0953e-18
c1485 n91__net23 vss 28.8201e-18
c1486 n2__i33__i19__net1 vss 38.8522e-18
c1487 n29__en_b vss 305.813e-18
c1488 n2__i29__net31 vss 107.036e-18
c1489 n1__out8 vss 45.5294e-18
c1490 n138__clk100m_b vss 31.9215e-18
c1491 n219__clk100m vss 29.226e-18
c1492 n221__clk100m vss 25.0571e-18
c1493 n7__i28__net12 vss 88.3298e-18
c1494 n85__net23 vss 32.1898e-18
c1495 n401__clk1pt6g vss 29.6206e-18
c1496 n403__clk1pt6g vss 24.8576e-18
c1497 n400__clk1pt6g vss 27.8799e-18
c1498 n65__net29 vss 23.0712e-18
c1499 n67__rst_b vss 114.537e-18
c1500 n3__i33__i21__x vss 40.8112e-18
c1501 n214__clk100m vss 23.2361e-18
c1502 n3__i29__i137__x vss 39.276e-18
c1503 n110__rst vss 285.383e-18
c1504 n108__rst vss 7.94946e-18
c1505 n2__i40__i50__x vss 59.354e-18
c1506 n134__clk100m_b vss 371.779e-18
c1507 n209__clk100m vss 31.7179e-18
c1508 n130__clk100m_b vss 131.454e-18
c1509 n132__clk100m_b vss 25.6041e-18
c1510 n29__i28__net3 vss 28.4948e-18
c1511 n57__net29 vss 28.2834e-18
c1512 n389__clk1pt6g vss 23.7407e-18
c1513 n26__i28__net3 vss 92.9835e-18
c1514 n11__i28__net23 vss 72.3133e-18
c1515 n26__en vss 438.72e-18
c1516 n388__clk1pt6g vss 31.5314e-18
c1517 n80__net23 vss 74.0953e-18
c1518 n82__net23 vss 26.5575e-18
c1519 n2__i33__i21__net1 vss 38.8522e-18
c1520 n26__en_b vss 305.512e-18
c1521 n2__i29__net15 vss 107.036e-18
c1522 n1__out7 vss 45.4818e-18
c1523 n5__i28__i71__x vss 61.8054e-18
c1524 n124__clk100m_b vss 31.9215e-18
c1525 n204__clk100m vss 29.226e-18
c1526 n206__clk100m vss 25.1606e-18
c1527 n76__net23 vss 32.1898e-18
c1528 n382__clk1pt6g vss 29.6206e-18
c1529 n384__clk1pt6g vss 26.7076e-18
c1530 n381__clk1pt6g vss 28.0088e-18
c1531 n56__net29 vss 23.0712e-18
c1532 n57__rst_b vss 114.537e-18
c1533 n3__i33__i20__x vss 40.8127e-18
c1534 n197__clk100m vss 23.2361e-18
c1535 n3__i29__i136__x vss 38.8387e-18
c1536 n94__rst vss 285.383e-18
c1537 n92__rst vss 7.94946e-18
c1538 n2__i40__i51__x vss 59.089e-18
c1539 n96__clk100m_b vss 371.687e-18
c1540 n192__clk100m vss 31.7179e-18
c1541 n92__clk100m_b vss 131.454e-18
c1542 n94__clk100m_b vss 25.7659e-18
c1543 n5__i28__net23 vss 76.5033e-18
c1544 n22__i28__net3 vss 80.856e-18
c1545 n48__net29 vss 26.368e-18
c1546 n370__clk1pt6g vss 23.7407e-18
c1547 n23__en vss 438.429e-18
c1548 n369__clk1pt6g vss 31.5314e-18
c1549 n71__net23 vss 74.0953e-18
c1550 n73__net23 vss 26.8298e-18
c1551 n2__i33__i20__net1 vss 38.8522e-18
c1552 n23__en_b vss 306.719e-18
c1553 n2__i29__net22 vss 107.036e-18
c1554 n1__out6 vss 45.4289e-18
c1555 n5__i28__net17 vss 52.4038e-18
c1556 n86__clk100m_b vss 31.9215e-18
c1557 n187__clk100m vss 29.226e-18
c1558 n189__clk100m vss 25.167e-18
c1559 n67__net23 vss 32.1898e-18
c1560 n363__clk1pt6g vss 29.6206e-18
c1561 n365__clk1pt6g vss 27.7245e-18
c1562 n362__clk1pt6g vss 28.33e-18
c1563 n47__net29 vss 23.0712e-18
c1564 n47__rst_b vss 29.2704e-18
c1565 n3__i33__i30__x vss 40.8127e-18
c1566 n182__clk100m vss 23.2361e-18
c1567 n3__i29__i135__x vss 39.2673e-18
c1568 n78__rst vss 285.509e-18
c1569 n76__rst vss 7.94946e-18
c1570 n2__i40__i52__x vss 59.5165e-18
c1571 n82__clk100m_b vss 371.741e-18
c1572 n177__clk100m vss 31.7179e-18
c1573 n78__clk100m_b vss 131.454e-18
c1574 n80__clk100m_b vss 25.7659e-18
c1575 n39__net29 vss 27.0689e-18
c1576 n351__clk1pt6g vss 23.7407e-18
c1577 n20__en vss 438.429e-18
c1578 n350__clk1pt6g vss 31.5314e-18
c1579 n62__net23 vss 74.0953e-18
c1580 n64__net23 vss 26.771e-18
c1581 n2__i33__i30__net1 vss 38.8522e-18
c1582 n20__en_b vss 306.719e-18
c1583 n2__i29__net30 vss 107.036e-18
c1584 n1__out5 vss 45.0434e-18
c1585 n72__clk100m_b vss 31.9215e-18
c1586 n172__clk100m vss 29.226e-18
c1587 n174__clk100m vss 25.167e-18
c1588 n7__i28__net3 vss 88.3578e-18
c1589 n58__net23 vss 32.1898e-18
c1590 n343__clk1pt6g vss 29.6206e-18
c1591 n345__clk1pt6g vss 26.43e-18
c1592 n340__clk1pt6g vss 28.1123e-18
c1593 n36__net29 vss 23.0712e-18
c1594 n37__rst_b vss 114.537e-18
c1595 n3__i33__i23__x vss 40.8127e-18
c1596 n167__clk100m vss 23.2361e-18
c1597 n3__i29__i134__x vss 38.763e-18
c1598 n62__rst vss 285.383e-18
c1599 n60__rst vss 7.94946e-18
c1600 n2__i40__i53__x vss 59.386e-18
c1601 n68__clk100m_b vss 371.687e-18
c1602 n162__clk100m vss 31.7179e-18
c1603 n64__clk100m_b vss 131.454e-18
c1604 n66__clk100m_b vss 25.7659e-18
c1605 n24__i28__net9 vss 29.4451e-18
c1606 n28__i28__net9 vss 76.8938e-18
c1607 n11__i28__net20 vss 72.0644e-18
c1608 n30__net29 vss 27.4089e-18
c1609 n328__clk1pt6g vss 23.7407e-18
c1610 n17__en vss 438.429e-18
c1611 n326__clk1pt6g vss 31.5314e-18
c1612 n53__net23 vss 74.0953e-18
c1613 n55__net23 vss 26.8143e-18
c1614 n2__i33__i23__net1 vss 38.8522e-18
c1615 n17__en_b vss 306.719e-18
c1616 n2__i29__net17 vss 107.071e-18
c1617 n1__out4 vss 45.4357e-18
c1618 n5__i28__i70__x vss 61.2048e-18
c1619 n58__clk100m_b vss 31.9215e-18
c1620 n157__clk100m vss 29.226e-18
c1621 n159__clk100m vss 25.167e-18
c1622 n47__net23 vss 32.1898e-18
c1623 n320__clk1pt6g vss 29.6206e-18
c1624 n322__clk1pt6g vss 26.9934e-18
c1625 n319__clk1pt6g vss 28.3158e-18
c1626 n29__net29 vss 23.0712e-18
c1627 n27__rst_b vss 29.2704e-18
c1628 n3__i33__i25__x vss 40.8127e-18
c1629 n152__clk100m vss 23.2361e-18
c1630 n3__i29__i133__x vss 38.7507e-18
c1631 n46__rst vss 285.383e-18
c1632 n44__rst vss 7.94946e-18
c1633 n2__i40__i54__x vss 59.1049e-18
c1634 n51__clk100m_b vss 371.741e-18
c1635 n5__i28__net20 vss 76.4686e-18
c1636 n22__i28__net9 vss 80.7631e-18
c1637 n149__clk100m vss 31.7179e-18
c1638 n47__clk100m_b vss 131.454e-18
c1639 n49__clk100m_b vss 25.7659e-18
c1640 n13__net29 vss 26.953e-18
c1641 n316__clk1pt6g vss 23.7407e-18
c1642 n14__en vss 438.429e-18
c1643 n315__clk1pt6g vss 31.5314e-18
c1644 n16__net23 vss 74.0953e-18
c1645 n18__net23 vss 26.8344e-18
c1646 n2__i33__i25__net1 vss 38.8522e-18
c1647 n14__en_b vss 306.719e-18
c1648 n2__i29__net10 vss 107e-18
c1649 n1__out3 vss 45.4289e-18
c1650 n5__i28__net15 vss 48.7731e-18
c1651 n41__clk100m_b vss 31.9215e-18
c1652 n144__clk100m vss 29.226e-18
c1653 n146__clk100m vss 25.167e-18
c1654 n15__net23 vss 32.1898e-18
c1655 n311__clk1pt6g vss 29.6206e-18
c1656 n313__clk1pt6g vss 27.4143e-18
c1657 n310__clk1pt6g vss 28.2565e-18
c1658 n12__net29 vss 23.0712e-18
c1659 n37__clk100m vss 48.4309e-18
c1660 n17__rst_b vss 114.537e-18
c1661 n3__i33__i24__x vss 40.8127e-18
c1662 n32__clk100m vss 23.2361e-18
c1663 n3__i29__i132__x vss 38.8125e-18
c1664 n30__rst vss 285.383e-18
c1665 n28__rst vss 7.94946e-18
c1666 n2__i40__i55__x vss 59.6089e-18
c1667 n37__clk100m_b vss 371.741e-18
c1668 n29__clk100m vss 31.7179e-18
c1669 n33__clk100m_b vss 131.456e-18
c1670 n35__clk100m_b vss 25.7659e-18
c1671 n9__net29 vss 26.6843e-18
c1672 n307__clk1pt6g vss 23.7407e-18
c1673 n11__en vss 438.429e-18
c1674 n306__clk1pt6g vss 31.5314e-18
c1675 n11__net23 vss 74.0953e-18
c1676 n13__net23 vss 26.559e-18
c1677 n2__i33__i24__net1 vss 38.8522e-18
c1678 n11__en_b vss 306.721e-18
c1679 n2__i29__net20 vss 107.036e-18
c1680 n1__out2 vss 45.5908e-18
c1681 n26__clk100m_b vss 31.9215e-18
c1682 n24__clk100m vss 29.2201e-18
c1683 n26__clk100m vss 25.1646e-18
c1684 n7__i28__net9 vss 88.3782e-18
c1685 n10__net23 vss 32.1898e-18
c1686 n299__clk1pt6g vss 29.6206e-18
c1687 n301__clk1pt6g vss 26.47e-18
c1688 n298__clk1pt6g vss 28.4424e-18
c1689 n8__net29 vss 23.0712e-18
c1690 n12__rst_b vss 29.2704e-18
c1691 n3__i33__i29__x vss 40.7904e-18
c1692 n23__clk100m vss 23.2361e-18
c1693 n3__i29__i131__x vss 38.8951e-18
c1694 n20__rst vss 285.383e-18
c1695 n18__rst vss 7.94946e-18
c1696 n2__i40__i56__x vss 59.2699e-18
c1697 n6__net22 vss 39.0298e-18
c1698 n23__clk100m_b vss 372.203e-18
c1699 n20__clk100m vss 31.7179e-18
c1700 n19__clk100m_b vss 131.495e-18
c1701 n21__clk100m_b vss 25.7622e-18
c1702 n10__net22 vss 77.3362e-18
c1703 n295__clk1pt6g vss 72.8593e-18
c1704 n5__net29 vss 24.7365e-18
c1705 n290__clk1pt6g vss 23.7407e-18
c1706 n8__en vss 438.408e-18
c1707 n289__clk1pt6g vss 31.5305e-18
c1708 n6__net23 vss 74.0953e-18
c1709 n8__net23 vss 25.9033e-18
c1710 n2__i33__i29__net1 vss 70.6837e-18
c1711 n8__en_b vss 306.623e-18
c1712 n2__i29__net27 vss 107.036e-18
c1713 n1__out1 vss 45.5757e-18
c1714 n5__i28__i69__x vss 62.1437e-18
c1715 n18__clk100m_b vss 31.9215e-18
c1716 n16__clk100m vss 29.1448e-18
c1717 n18__clk100m vss 25.1646e-18
c1718 n5__net23 vss 32.2151e-18
c1719 n279__clk1pt6g vss 29.6227e-18
c1720 n281__clk1pt6g vss 26.5929e-18
c1721 n278__clk1pt6g vss 28.0571e-18
c1722 n4__net29 vss 23.1141e-18
c1723 n9__rst_b vss 114.537e-18
c1724 n3__i33__i26__x vss 40.7904e-18
c1725 n15__clk100m vss 22.4577e-18
c1726 n3__i29__i130__x vss 39.3322e-18
c1727 n15__rst vss 285.383e-18
c1728 n13__rst vss 7.94946e-18
c1729 n2__i40__i57__x vss 57.9401e-18
c1730 n270__clk1pt6g vss 35.0454e-18
c1731 n15__clk100m_b vss 296.655e-18
c1732 n274__clk1pt6g vss 76.8007e-18
c1733 n4__net22 vss 80.8718e-18
c1734 n12__clk100m vss 31.7179e-18
c1735 n11__clk100m_b vss 131.469e-18
c1736 n13__clk100m_b vss 25.7622e-18
c1737 n268__clk1pt6g vss 21.1468e-18
c1738 n5__en vss 437.724e-18
c1739 n267__clk1pt6g vss 31.4212e-18
c1740 n3__net23 vss 26.172e-18
c1741 n2__i33__i26__net1 vss 38.8642e-18
c1742 n5__en_b vss 307.521e-18
c1743 n2__net18 vss 77.7365e-18
c1744 n5__i28__net1 vss 29.7645e-18
c1745 n10__clk100m_b vss 31.9215e-18
c1746 n8__clk100m vss 29.1919e-18
c1747 n10__clk100m vss 25.4308e-18
c1748 n6__rst_b vss 29.2408e-18
c1749 n3__i33__i28__x vss 40.5845e-18
c1750 n10__rst vss 283.963e-18
c1751 n8__rst vss 7.94105e-18
c1752 n7__clk100m vss 32.3744e-18
c1753 n6__clk100m_b vss 133.126e-18
c1754 n8__clk100m_b vss 25.713e-18
c1755 n1__en vss 267.432e-18
c1756 n2__i33__i28__net1 vss 38.8816e-18
c1757 n1__en_b vss 174.36e-18
c1758 n5__clk100m_b vss 31.8697e-18
c1759 n3__clk100m vss 29.7671e-18
c1760 n5__clk100m vss 24.1526e-18
c1761 n3__rst_b vss 30.8088e-18
c1762 n3__i33__i27__x vss 39.9333e-18
c1763 n5__rst vss 24.7771e-18
c1764 n3__rst vss 8.90509e-18
c1765 n2__clk100m vss 32.1218e-18
c1766 n3__clk100m_b vss 25.8112e-18
c1767 n226__clk1pt6g vss 10.8772e-18
c1768 n2__i33__i27__net1 vss 40.3241e-18
c1769 n8__i33__xor2 vss 27.8574e-18
c1770 n3__i33__i56__net1 vss 12.3823e-18
c1771 n2__i33__i56__net1 vss 29.293e-18
c1772 n6__i33__xor2 vss 10.4355e-18
c1773 n3__i33__xor1 vss 12.0719e-18
c1774 n127__clk1pt6g vss 18.2418e-18
c1775 n20__clk1pt6g vss 17.6994e-18
c1776 n9__net17 vss 53.1034e-18
c1777 n3__net17 vss 9.77447e-18
c1778 n5__i33__i57__net1 vss 28.4325e-18
c1779 n8__net5 vss 57.3292e-18
c1780 n3__i33__i57__net1 vss 10.3663e-18
c1781 n2__net17 vss 27.6922e-18
c1782 n3__net5 vss 53.4676e-18
c1783 n5__i33__i58__net1 vss 23.3521e-18
c1784 n3__i33__i58__net1 vss 54.0322e-18
c1785 n2__net5 vss 24.6685e-18
c1786 n160__rst_b vss 50.3772e-18
c1787 n159__rst_b vss 85.4379e-18
c1788 n158__rst_b vss 85.4379e-18
c1789 n36__net5 vss 834.455e-18
c1790 n139__rst_b vss 97.4339e-18
c1791 n123__rst_b vss 100.532e-18
c1792 n113__rst_b vss 100.532e-18
c1793 n103__rst_b vss 100.532e-18
c1794 n93__rst_b vss 100.532e-18
c1795 n83__rst_b vss 101.157e-18
c1796 n73__rst_b vss 100.532e-18
c1797 n63__rst_b vss 100.344e-18
c1798 n53__rst_b vss 100.532e-18
c1799 n43__rst_b vss 102.042e-18
c1800 n33__rst_b vss 101.692e-18
c1801 n23__rst_b vss 103.195e-18
c1802 n13__rst_b vss 122.845e-18
c1803 n13__net5 vss 699.283e-18
c1804 n155__net29 vss 80.1812e-18
c1805 n154__net29 vss 53.1973e-18
c1806 n157__rst_b vss 79.8454e-18
c1807 n251__clk100m_b vss 94.6744e-18
c1808 n153__net29 vss 78.9752e-18
c1809 n629__clk1pt6g vss 47.6656e-18
c1810 n25__net2 vss 98.5407e-18
c1811 n25__net3 vss 146.6e-18
c1812 n156__rst_b vss 88.5088e-18
c1813 n250__clk100m_b vss 118.954e-18
c1814 n152__net29 vss 57.3174e-18
c1815 n78__net22 vss 118.945e-18
c1816 n24__net3 vss 119.862e-18
c1817 n12__net4 vss 148.827e-18
c1818 n145__rst_b vss 88.5088e-18
c1819 n238__clk100m_b vss 117.466e-18
c1820 n132__net29 vss 46.567e-18
c1821 n566__clk1pt6g vss 7.53833e-18
c1822 n10__net4 vss 146.292e-18
c1823 n35__net5 vss 59.9736e-18
c1824 n138__rst_b vss 89.5598e-18
c1825 n228__clk100m_b vss 67.5739e-18
c1826 n124__net29 vss 54.1952e-18
c1827 n71__net22 vss 50.7081e-18
c1828 n24__net5 vss 94.5256e-18
c1829 n12__net6 vss 167.609e-18
c1830 n124__rst_b vss 89.5598e-18
c1831 n214__clk100m_b vss 121.277e-18
c1832 n115__net29 vss 57.6026e-18
c1833 n10__net6 vss 125.685e-18
c1834 n12__net7 vss 166.621e-18
c1835 n114__rst_b vss 89.5598e-18
c1836 n200__clk100m_b vss 121.396e-18
c1837 n106__net29 vss 46.5702e-18
c1838 n10__net7 vss 125.711e-18
c1839 n12__net8 vss 166.621e-18
c1840 n104__rst_b vss 89.5598e-18
c1841 n186__clk100m_b vss 67.397e-18
c1842 n97__net29 vss 54.1363e-18
c1843 n10__net8 vss 125.711e-18
c1844 n12__net9 vss 166.621e-18
c1845 n94__rst_b vss 89.5598e-18
c1846 n170__clk100m_b vss 121.277e-18
c1847 n88__net29 vss 57.339e-18
c1848 n10__net9 vss 125.711e-18
c1849 n12__net10 vss 166.621e-18
c1850 n84__rst_b vss 89.5598e-18
c1851 n156__clk100m_b vss 121.277e-18
c1852 n79__net29 vss 46.8866e-18
c1853 n10__net10 vss 125.711e-18
c1854 n12__net11 vss 166.621e-18
c1855 n74__rst_b vss 89.5598e-18
c1856 n142__clk100m_b vss 67.5532e-18
c1857 n70__net29 vss 53.9597e-18
c1858 n10__net11 vss 125.711e-18
c1859 n12__net12 vss 166.621e-18
c1860 n64__rst_b vss 89.5598e-18
c1861 n127__clk100m_b vss 121.339e-18
c1862 n61__net29 vss 57.2723e-18
c1863 n10__net12 vss 125.703e-18
c1864 n12__net13 vss 166.621e-18
c1865 n54__rst_b vss 89.5598e-18
c1866 n90__clk100m_b vss 127.413e-18
c1867 n52__net29 vss 48.9668e-18
c1868 n10__net13 vss 125.726e-18
c1869 n24__net14 vss 613.914e-18
c1870 n44__rst_b vss 90.4123e-18
c1871 n44__net22 vss 680.407e-18
c1872 n76__clk100m_b vss 181.586e-18
c1873 n43__net29 vss 53.6076e-18
c1874 n20__net14 vss 124.529e-18
c1875 n12__net15 vss 177.341e-18
c1876 n34__rst_b vss 90.4123e-18
c1877 n334__clk1pt6g vss 947.783e-18
c1878 n61__clk100m_b vss 181.795e-18
c1879 n34__net29 vss 53.7669e-18
c1880 n648__clk1pt6g vss 98.2222e-18
c1881 n52__net23 vss 123.987e-18
c1882 n10__net15 vss 128.224e-18
c1883 n34__net16 vss 329.027e-18
c1884 n630__clk1pt6g vss 144.242e-18
c1885 n24__rst_b vss 90.127e-18
c1886 n45__net23 vss 61.8741e-18
c1887 n44__clk100m_b vss 172.653e-18
c1888 n39__net22 vss 172.41e-18
c1889 n23__net16 vss 124.89e-18
c1890 n6__vdd vss 71.5364e-18
c1891 n14__rst_b vss 65.8574e-18
c1892 n304__clk1pt6g vss 158.557e-18
c1893 n18__i33__xor1 vss 128.854e-18
c1894 n3__vdd vss 63.6683e-18
c1895 n10__net16 vss 226.416e-18
c1896 n13__i33__xor1 vss 135.089e-18
c1897 n286__clk1pt6g vss 116.77e-18
c1898 n287__clk1pt6g vss 116.232e-18
c1899 n12__net14 vss 449.724e-18
c1900 n9__net16 vss 53.2278e-18
c1901 n10__i33__xor1 vss 98.788e-18
c1902 n12__net5 vss 13.5838e-18
c1903 n9__net14 vss 127.548e-18
c1904 n17__net20 vss 152.994e-18
c1905 n16__net20 vss 70.7796e-18
c1906 n627__clk1pt6g vss 59.3497e-18
c1907 n628__clk1pt6g vss 71.1436e-18
c1908 n14__net20 vss 76.0418e-18
c1909 n15__net20 vss 78.9079e-18
c1910 n151__net29 vss 21.944e-18
c1911 n626__clk1pt6g vss 21.8269e-18
c1912 n624__clk1pt6g vss 121.03e-18
c1913 n625__clk1pt6g vss 62.8917e-18
c1914 n13__net37 vss 46.3577e-18
c1915 n12__net37 vss 90.1343e-18
c1916 n369__clk100m vss 95.889e-18
c1917 n24__net2 vss 50.1933e-18
c1918 n11__net37 vss 41.8274e-18
c1919 n149__net29 vss 21.6063e-18
c1920 n623__clk1pt6g vss 21.8269e-18
c1921 n23__i28__net6 vss 99.5142e-18
c1922 n24__i28__net6 vss 78.2928e-18
c1923 n19__net2 vss 103.951e-18
c1924 n21__net2 vss 105e-18
c1925 n15__i28__net5 vss 155.79e-18
c1926 n23__net2 vss 23.8247e-18
c1927 n368__clk100m vss 52.8209e-18
c1928 n256__rst vss 48.785e-18
c1929 n621__clk1pt6g vss 62.5138e-18
c1930 n622__clk1pt6g vss 66.934e-18
c1931 n13__net36 vss 105.752e-18
c1932 n155__rst_b vss 35.8968e-18
c1933 n12__net36 vss 106.335e-18
c1934 n12__i33__i0__net1 vss 129.912e-18
c1935 n367__clk100m vss 110.335e-18
c1936 n255__rst vss 51.8672e-18
c1937 n23__net3 vss 48.9321e-18
c1938 n11__net36 vss 74.3428e-18
c1939 n620__clk1pt6g vss 21.8483e-18
c1940 n39__i28__net13 vss 116.599e-18
c1941 n11__i33__i0__net1 vss 217.447e-18
c1942 n619__clk1pt6g vss 5.75937e-18
c1943 n18__net2 vss 70.6505e-18
c1944 n22__net3 vss 52.1233e-18
c1945 n366__clk100m vss 11.2373e-18
c1946 n254__rst vss 60.6492e-18
c1947 n617__clk1pt6g vss 51.3529e-18
c1948 n618__clk1pt6g vss 109.291e-18
c1949 n13__net35 vss 47.6797e-18
c1950 n152__rst_b vss 35.673e-18
c1951 n12__net35 vss 47.6891e-18
c1952 n12__i33__i16__net1 vss 131.639e-18
c1953 n365__clk100m vss 82.6436e-18
c1954 n253__rst vss 55.9276e-18
c1955 n25__net4 vss 49.0117e-18
c1956 n11__net35 vss 41.7522e-18
c1957 n146__net29 vss 26.3582e-18
c1958 n616__clk1pt6g vss 21.8269e-18
c1959 n75__net22 vss 30.9742e-18
c1960 n8__i33__i16__net1 vss 219.284e-18
c1961 n28__i28__net7 vss 123.922e-18
c1962 n9__net3 vss 70.5854e-18
c1963 n11__net4 vss 52.6883e-18
c1964 n353__clk100m vss 11.2373e-18
c1965 n229__rst vss 60.6492e-18
c1966 n10__i28__net5 vss 130.737e-18
c1967 n577__clk1pt6g vss 55.0902e-18
c1968 n584__clk1pt6g vss 66.9374e-18
c1969 n13__net34 vss 105.733e-18
c1970 n144__rst_b vss 35.673e-18
c1971 n9__net34 vss 47.6891e-18
c1972 n12__i33__i18__net1 vss 217.615e-18
c1973 n349__clk100m vss 82.6436e-18
c1974 n228__rst vss 55.9276e-18
c1975 n40__net5 vss 49.0117e-18
c1976 n4__net34 vss 41.7522e-18
c1977 n131__net29 vss 22.469e-18
c1978 n573__clk1pt6g vss 21.8269e-18
c1979 n565__clk1pt6g vss 26.4441e-18
c1980 n5__i33__i18__net1 vss 218.108e-18
c1981 n15__i28__net19 vss 143.796e-18
c1982 n35__i28__net13 vss 119.822e-18
c1983 n34__net5 vss 51.7111e-18
c1984 n346__clk100m vss 37.7362e-18
c1985 n218__rst vss 60.7657e-18
c1986 n554__clk1pt6g vss 105.044e-18
c1987 n556__clk1pt6g vss 66.6686e-18
c1988 n10__net33 vss 105.733e-18
c1989 n137__rst_b vss 35.673e-18
c1990 n5__net33 vss 106.335e-18
c1991 n12__i33__i17__net1 vss 131.445e-18
c1992 n339__clk100m vss 82.6436e-18
c1993 n217__rst vss 55.595e-18
c1994 n22__net6 vss 49.0117e-18
c1995 n4__net33 vss 41.7522e-18
c1996 n227__clk100m_b vss 53.7242e-18
c1997 n38__i28__net12 vss 256.474e-18
c1998 n123__net29 vss 109.592e-18
c1999 n549__clk1pt6g vss 21.8698e-18
c2000 n70__net22 vss 16.9337e-18
c2001 n5__i33__i17__net1 vss 220.73e-18
c2002 n23__net5 vss 70.5199e-18
c2003 n11__net6 vss 51.6969e-18
c2004 n333__clk100m vss 11.8662e-18
c2005 n207__rst vss 60.7657e-18
c2006 n531__clk1pt6g vss 104.548e-18
c2007 n541__clk1pt6g vss 71.2231e-18
c2008 n10__net32 vss 105.733e-18
c2009 n132__rst_b vss 35.673e-18
c2010 n26__i28__net7 vss 132.054e-18
c2011 n9__net32 vss 47.6891e-18
c2012 n12__i33__i22__net1 vss 217.383e-18
c2013 n326__clk100m vss 82.6436e-18
c2014 n200__rst vss 55.5893e-18
c2015 n22__net7 vss 49.0117e-18
c2016 n4__net32 vss 74.3428e-18
c2017 n114__net29 vss 111.236e-18
c2018 n523__clk1pt6g vss 52.9889e-18
c2019 n5__i33__i22__net1 vss 128.544e-18
c2020 n9__net6 vss 70.5199e-18
c2021 n11__net7 vss 51.6969e-18
c2022 n318__clk100m vss 37.7362e-18
c2023 n10__i28__net19 vss 129.84e-18
c2024 n191__rst vss 60.7657e-18
c2025 n505__clk1pt6g vss 53.6588e-18
c2026 n515__clk1pt6g vss 66.7837e-18
c2027 n10__net31 vss 105.733e-18
c2028 n122__rst_b vss 35.673e-18
c2029 n6__net31 vss 47.6891e-18
c2030 n12__i33__i19__net1 vss 217.383e-18
c2031 n311__clk100m vss 82.6436e-18
c2032 n184__rst vss 55.5893e-18
c2033 n22__net8 vss 49.0117e-18
c2034 n4__net31 vss 74.3428e-18
c2035 n105__net29 vss 22.4502e-18
c2036 n499__clk1pt6g vss 21.8269e-18
c2037 n5__i33__i19__net1 vss 128.544e-18
c2038 n15__i28__net17 vss 144.261e-18
c2039 n35__i28__net12 vss 128.718e-18
c2040 n9__net7 vss 70.5199e-18
c2041 n11__net8 vss 51.6969e-18
c2042 n303__clk100m vss 54.2481e-18
c2043 n175__rst vss 60.7657e-18
c2044 n481__clk1pt6g vss 60.9886e-18
c2045 n486__clk1pt6g vss 66.8188e-18
c2046 n10__net30 vss 47.6797e-18
c2047 n112__rst_b vss 35.673e-18
c2048 n9__net30 vss 106.335e-18
c2049 n12__i33__i21__net1 vss 131.406e-18
c2050 n295__clk100m vss 82.6436e-18
c2051 n168__rst vss 55.5893e-18
c2052 n22__net9 vss 48.873e-18
c2053 n4__net30 vss 74.3428e-18
c2054 n185__clk100m_b vss 53.203e-18
c2055 n38__i28__net3 vss 245.87e-18
c2056 n96__net29 vss 24.9892e-18
c2057 n473__clk1pt6g vss 21.8269e-18
c2058 n5__i33__i21__net1 vss 220.19e-18
c2059 n9__net8 vss 70.5199e-18
c2060 n11__net9 vss 51.6969e-18
c2061 n287__clk100m vss 12.0376e-18
c2062 n159__rst vss 60.7657e-18
c2063 n455__clk1pt6g vss 64.8267e-18
c2064 n460__clk1pt6g vss 71.2522e-18
c2065 n10__net43 vss 105.733e-18
c2066 n102__rst_b vss 35.673e-18
c2067 n9__net43 vss 47.6891e-18
c2068 n12__i33__i20__net1 vss 217.383e-18
c2069 n280__clk100m vss 82.6436e-18
c2070 n152__rst vss 55.5893e-18
c2071 n22__net10 vss 49.0117e-18
c2072 n4__net43 vss 41.7522e-18
c2073 n87__net29 vss 110.926e-18
c2074 n449__clk1pt6g vss 21.8269e-18
c2075 n5__i33__i20__net1 vss 220.19e-18
c2076 n9__net9 vss 70.5199e-18
c2077 n11__net10 vss 51.6969e-18
c2078 n272__clk100m vss 37.7362e-18
c2079 n10__i28__net17 vss 168.717e-18
c2080 n143__rst vss 61.1871e-18
c2081 n434__clk1pt6g vss 115.889e-18
c2082 n436__clk1pt6g vss 67.0469e-18
c2083 n10__net42 vss 105.733e-18
c2084 n92__rst_b vss 35.673e-18
c2085 n9__net42 vss 47.6891e-18
c2086 n12__i33__i30__net1 vss 217.383e-18
c2087 n265__clk100m vss 82.6436e-18
c2088 n136__rst vss 55.5893e-18
c2089 n22__net11 vss 49.0117e-18
c2090 n4__net42 vss 41.7522e-18
c2091 n78__net29 vss 22.5775e-18
c2092 n430__clk1pt6g vss 21.8269e-18
c2093 n5__i33__i30__net1 vss 220.19e-18
c2094 n15__i28__net15 vss 142.513e-18
c2095 n35__i28__net3 vss 119.528e-18
c2096 n9__net10 vss 70.5199e-18
c2097 n11__net11 vss 51.6969e-18
c2098 n233__clk100m vss 11.8662e-18
c2099 n127__rst vss 60.7657e-18
c2100 n412__clk1pt6g vss 115.174e-18
c2101 n417__clk1pt6g vss 66.9445e-18
c2102 n10__net41 vss 105.733e-18
c2103 n82__rst_b vss 35.673e-18
c2104 n9__net41 vss 106.335e-18
c2105 n12__i33__i23__net1 vss 217.383e-18
c2106 n226__clk100m vss 82.6436e-18
c2107 n120__rst vss 55.5893e-18
c2108 n22__net12 vss 49.0117e-18
c2109 n4__net41 vss 74.3428e-18
c2110 n141__clk100m_b vss 107.686e-18
c2111 n38__i28__net9 vss 274.692e-18
c2112 n69__net29 vss 24.9936e-18
c2113 n411__clk1pt6g vss 21.8376e-18
c2114 n5__i33__i23__net1 vss 220.19e-18
c2115 n9__net11 vss 70.5199e-18
c2116 n11__net12 vss 51.6969e-18
c2117 n218__clk100m vss 11.8662e-18
c2118 n111__rst vss 60.7657e-18
c2119 n393__clk1pt6g vss 65.4101e-18
c2120 n398__clk1pt6g vss 71.1581e-18
c2121 n10__net40 vss 105.733e-18
c2122 n72__rst_b vss 35.673e-18
c2123 n9__net40 vss 47.6891e-18
c2124 n12__i33__i25__net1 vss 217.38e-18
c2125 n211__clk100m vss 82.6436e-18
c2126 n104__rst vss 55.5893e-18
c2127 n22__net13 vss 49.0117e-18
c2128 n4__net40 vss 74.3428e-18
c2129 n60__net29 vss 26.3172e-18
c2130 n392__clk1pt6g vss 21.8376e-18
c2131 n5__i33__i25__net1 vss 128.544e-18
c2132 n9__net12 vss 70.5199e-18
c2133 n11__net13 vss 51.6969e-18
c2134 n201__clk100m vss 11.8662e-18
c2135 n202__clk100m vss 225.989e-18
c2136 n10__i28__net15 vss 138.914e-18
c2137 n95__rst vss 60.7657e-18
c2138 n374__clk1pt6g vss 63.3739e-18
c2139 n379__clk1pt6g vss 65.915e-18
c2140 n10__net39 vss 47.6797e-18
c2141 n62__rst_b vss 35.673e-18
c2142 n9__net39 vss 47.6891e-18
c2143 n12__i33__i24__net1 vss 217.383e-18
c2144 n194__clk100m vss 82.6436e-18
c2145 n88__rst vss 55.5893e-18
c2146 n34__net14 vss 49.0117e-18
c2147 n4__net39 vss 74.3428e-18
c2148 n51__net29 vss 22.3921e-18
c2149 n373__clk1pt6g vss 21.8269e-18
c2150 n5__i33__i24__net1 vss 219.898e-18
c2151 n16__i28__net1 vss 140.882e-18
c2152 n35__i28__net9 vss 199.633e-18
c2153 n9__net13 vss 70.5252e-18
c2154 n23__net14 vss 51.66e-18
c2155 n184__clk100m vss 13.6952e-18
c2156 n79__rst vss 60.7657e-18
c2157 n355__clk1pt6g vss 62.7907e-18
c2158 n360__clk1pt6g vss 67.0811e-18
c2159 n10__net38 vss 105.733e-18
c2160 n50__rst_b vss 35.8377e-18
c2161 n9__net38 vss 47.6891e-18
c2162 n12__i33__i29__net1 vss 217.378e-18
c2163 n179__clk100m vss 82.6436e-18
c2164 n72__rst vss 55.5893e-18
c2165 n22__net15 vss 119.524e-18
c2166 n43__net22 vss 15.2309e-18
c2167 n4__net38 vss 41.7522e-18
c2168 n42__net29 vss 24.9948e-18
c2169 n354__clk1pt6g vss 21.8698e-18
c2170 n5__i33__i29__net1 vss 222.104e-18
c2171 n19__net14 vss 138.142e-18
c2172 n11__net15 vss 51.66e-18
c2173 n171__clk100m vss 14.1665e-18
c2174 n63__rst vss 60.7667e-18
c2175 n335__clk1pt6g vss 120.897e-18
c2176 n342__clk1pt6g vss 69.1491e-18
c2177 n10__net19 vss 52.2626e-18
c2178 n42__rst_b vss 35.8377e-18
c2179 n9__net19 vss 47.6789e-18
c2180 n12__i33__i26__net1 vss 217.383e-18
c2181 n164__clk100m vss 81.8937e-18
c2182 n333__clk1pt6g vss 37.5439e-18
c2183 n56__rst vss 55.6087e-18
c2184 n35__net16 vss 49.1953e-18
c2185 n4__net19 vss 46.2536e-18
c2186 n62__clk100m_b vss 53.9133e-18
c2187 n331__clk1pt6g vss 31.6028e-18
c2188 n51__net23 vss 130.226e-18
c2189 n5__i33__i26__net1 vss 221.518e-18
c2190 n9__net18 vss 163.852e-18
c2191 n9__net15 vss 69.5202e-18
c2192 n33__net16 vss 51.8007e-18
c2193 n156__clk100m vss 18.4813e-18
c2194 n10__i28__net1 vss 122.743e-18
c2195 n47__rst vss 60.9357e-18
c2196 n32__rst_b vss 36.3598e-18
c2197 n8__net18 vss 171.323e-18
c2198 n12__i33__i28__net1 vss 130.816e-18
c2199 n40__rst vss 54.9123e-18
c2200 n22__net17 vss 60.5354e-18
c2201 n44__net23 vss 18.4567e-18
c2202 n45__clk100m_b vss 199.286e-18
c2203 n38__net22 vss 11.9418e-18
c2204 n4__i33__i28__net1 vss 182.691e-18
c2205 n18__net17 vss 61.5427e-18
c2206 n22__net16 vss 24.6035e-18
c2207 n33__clk100m vss 18.1124e-18
c2208 n5__vdd vss 70.3002e-18
c2209 n31__rst vss 60.5814e-18
c2210 n20__rst_b vss 39.0405e-18
c2211 n12__i33__i27__net1 vss 122.054e-18
c2212 n24__rst vss 52.5606e-18
c2213 n30__clk100m_b vss 275.74e-18
c2214 n303__clk1pt6g vss 25.6865e-18
c2215 n5__i33__i27__net1 vss 89.3251e-18
c2216 n16__i33__i56__net1 vss 173.917e-18
c2217 n13__net16 vss 304.86e-18
c2218 n12__i33__i56__net1 vss 154.446e-18
c2219 n8__i33__i56__net2 vss 62.7788e-18
c2220 n2__vdd vss 125.772e-18
c2221 n4__i33__i56__net2 vss 59.0143e-18
c2222 n12__i33__xor1 vss 39.2905e-18
c2223 n284__clk1pt6g vss 8.56142e-18
c2224 n285__clk1pt6g vss 11.8968e-18
c2225 n8__i33__i57__net2 vss 117.238e-18
c2226 n11__net14 vss 36.3786e-18
c2227 n8__i33__i58__net2 vss 109.248e-18
c2228 n4__i33__i57__net2 vss 60.3148e-18
c2229 n11__i33__i57__net1 vss 137.656e-18
c2230 n10__i33__i57__net1 vss 90.2248e-18
c2231 n8__net16 vss 122.317e-18
c2232 n4__i33__i58__net2 vss 64.2052e-18
c2233 n11__i33__i58__net1 vss 149.271e-18
c2234 n9__i33__xor1 vss 29.884e-18
c2235 n7__i33__i58__net1 vss 166.787e-18
c2236 n9__net28 vss 159.232e-18
c2237 n10__net20 vss 142.531e-18
c2238 n7__net20 vss 92.1322e-18
c2239 n13__net20 vss 94.6364e-18
c2240 n12__net21 vss 244.785e-18
c2241 n173__net23 vss 136.211e-18
c2242 n612__clk1pt6g vss 176.949e-18
c2243 n614__clk1pt6g vss 74.173e-18
c2244 n615__clk1pt6g vss 127.803e-18
c2245 n144__net29 vss 156.73e-18
c2246 n6__net20 vss 101.763e-18
c2247 n172__net23 vss 118.101e-18
c2248 n143__net29 vss 183.816e-18
c2249 n611__clk1pt6g vss 96.3494e-18
c2250 n298__vdd vss 60.5429e-18
c2251 n610__clk1pt6g vss 134.278e-18
c2252 n171__net23 vss 188.547e-18
c2253 n7__out15 vss 54.9465e-18
c2254 n7__net28 vss 248.599e-18
c2255 n9__i29__net7 vss 164.301e-18
c2256 n169__net23 vss 148.098e-18
c2257 n605__clk1pt6g vss 165.953e-18
c2258 n606__clk1pt6g vss 91.6425e-18
c2259 n608__clk1pt6g vss 133.469e-18
c2260 n142__net29 vss 159.695e-18
c2261 n8__i29__net7 vss 16.2368e-18
c2262 n10__net37 vss 158.466e-18
c2263 n4__net37 vss 63.4994e-18
c2264 n364__clk100m vss 143.733e-18
c2265 n261__vdd vss 110.165e-18
c2266 n255__vdd vss 96.5183e-18
c2267 n15__net2 vss 169.366e-18
c2268 n3__i29__net7 vss 82.1839e-18
c2269 n3__net37 vss 117.867e-18
c2270 n168__net23 vss 120.145e-18
c2271 n141__net29 vss 173.365e-18
c2272 n604__clk1pt6g vss 96.0195e-18
c2273 n602__clk1pt6g vss 198.087e-18
c2274 n166__net23 vss 104.929e-18
c2275 n22__i28__net6 vss 86.1574e-18
c2276 n21__i28__net6 vss 53.0947e-18
c2277 n10__net21 vss 267.494e-18
c2278 n7__out14 vss 54.8243e-18
c2279 n12__net2 vss 72.4445e-18
c2280 n253__vdd vss 154.528e-18
c2281 n650__vdd vss 106.407e-18
c2282 n604__vdd vss 102.066e-18
c2283 n10__net2 vss 42.8306e-18
c2284 n11__i28__net5 vss 18.1435e-18
c2285 n251__rst vss 116.198e-18
c2286 n9__i29__net13 vss 162.632e-18
c2287 n247__clk100m_b vss 148.541e-18
c2288 n361__clk100m vss 191.649e-18
c2289 n362__clk100m vss 112.242e-18
c2290 n10__i33__d0 vss 1.39855e-15
c2291 n248__rst vss 134.465e-18
c2292 n165__net23 vss 147.994e-18
c2293 n598__clk1pt6g vss 166.141e-18
c2294 n599__clk1pt6g vss 132.767e-18
c2295 n601__clk1pt6g vss 138.194e-18
c2296 n140__net29 vss 159.695e-18
c2297 n6__i28__i52__net3 vss 91.5644e-18
c2298 n8__i29__net13 vss 16.3983e-18
c2299 n10__net36 vss 99.9726e-18
c2300 n149__rst_b vss 44.135e-18
c2301 n4__net36 vss 65.9267e-18
c2302 n9__i33__i0__net1 vss 202.181e-18
c2303 n6__i28__i51__net5 vss 76.2088e-18
c2304 n360__clk100m vss 116.232e-18
c2305 n597__clk1pt6g vss 283.095e-18
c2306 n77__net22 vss 195.735e-18
c2307 n247__rst vss 157.935e-18
c2308 n246__rst vss 151.48e-18
c2309 n8__i33__d0 vss 122.709e-18
c2310 n263__vdd vss 157e-18
c2311 n151__vdd vss 111.582e-18
c2312 n16__net3 vss 172.077e-18
c2313 n246__clk100m_b vss 81.3301e-18
c2314 n6__i28__i52__net2 vss 155.732e-18
c2315 n4__i28__i52__net3 vss 109.937e-18
c2316 n3__i29__net13 vss 82.0952e-18
c2317 n3__net36 vss 85.2764e-18
c2318 n359__clk100m vss 266.201e-18
c2319 n244__clk100m_b vss 144.188e-18
c2320 n164__net23 vss 120.035e-18
c2321 n139__net29 vss 192.365e-18
c2322 n596__clk1pt6g vss 95.9914e-18
c2323 n38__i28__net13 vss 100.633e-18
c2324 n594__clk1pt6g vss 197.719e-18
c2325 n162__net23 vss 107.036e-18
c2326 n7__i28__i51__net4 vss 97.5017e-18
c2327 n4__i28__i51__net5 vss 83.9116e-18
c2328 n593__clk1pt6g vss 62.1431e-18
c2329 n7__out13 vss 54.6783e-18
c2330 n37__i28__net13 vss 212.127e-18
c2331 n19__i28__net11 vss 313.948e-18
c2332 n13__net3 vss 149.423e-18
c2333 n149__vdd vss 154.462e-18
c2334 n2__i28__i52__net3 vss 104.699e-18
c2335 n2__i28__i52__net2 vss 147.749e-18
c2336 n11__net3 vss 224.537e-18
c2337 n6__net2 vss 67.642e-18
c2338 n2__i28__i51__net4 vss 83.5279e-18
c2339 n2__i28__i51__net5 vss 97.3463e-18
c2340 n242__rst vss 136.595e-18
c2341 n9__i29__net18 vss 162.632e-18
c2342 n243__clk100m_b vss 147.434e-18
c2343 n356__clk100m vss 195.107e-18
c2344 n357__clk100m vss 113.677e-18
c2345 n7__net2 vss 207.033e-18
c2346 n239__rst vss 134.009e-18
c2347 n161__net23 vss 149.291e-18
c2348 n589__clk1pt6g vss 166.138e-18
c2349 n590__clk1pt6g vss 133.674e-18
c2350 n6__i28__i52__net5 vss 95.2949e-18
c2351 n592__clk1pt6g vss 108.134e-18
c2352 n138__net29 vss 159.613e-18
c2353 n8__i29__net18 vss 16.3983e-18
c2354 n10__net35 vss 158.026e-18
c2355 n147__rst_b vss 129.683e-18
c2356 n4__net35 vss 124.573e-18
c2357 n6__i28__i51__net3 vss 110.694e-18
c2358 n10__i33__i16__net1 vss 202.295e-18
c2359 n76__net22 vss 199.969e-18
c2360 n588__clk1pt6g vss 303.323e-18
c2361 n355__clk100m vss 143.662e-18
c2362 n238__rst vss 157.613e-18
c2363 n237__rst vss 152.448e-18
c2364 n4__net2 vss 127.906e-18
c2365 n7__i28__i52__net4 vss 91.2017e-18
c2366 n4__i28__i52__net5 vss 81.6205e-18
c2367 n265__vdd vss 157.148e-18
c2368 n143__vdd vss 111.586e-18
c2369 n22__net4 vss 172.077e-18
c2370 n242__clk100m_b vss 81.3237e-18
c2371 n3__i29__net18 vss 82.0952e-18
c2372 n3__net35 vss 117.867e-18
c2373 n18__i28__net11 vss 184.195e-18
c2374 n354__clk100m vss 265.891e-18
c2375 n240__clk100m_b vss 143.914e-18
c2376 n160__net23 vss 121.847e-18
c2377 n137__net29 vss 192.634e-18
c2378 n587__clk1pt6g vss 95.9988e-18
c2379 n6__i28__i51__net2 vss 163.075e-18
c2380 n4__i28__i51__net3 vss 116.741e-18
c2381 n585__clk1pt6g vss 198.425e-18
c2382 n158__net23 vss 108.527e-18
c2383 n74__net22 vss 44.4586e-18
c2384 n5__i33__i16__net1 vss 41.1814e-18
c2385 n17__i28__net11 vss 297.632e-18
c2386 n36__i28__net13 vss 208.307e-18
c2387 n5__out12 vss 54.7181e-18
c2388 n2__i28__i52__net4 vss 87.5632e-18
c2389 n2__i28__i52__net5 vss 83.5858e-18
c2390 n16__net4 vss 72.7383e-18
c2391 n141__vdd vss 154.462e-18
c2392 n27__i28__net7 vss 76.4406e-18
c2393 n14__net4 vss 225.137e-18
c2394 n2__i28__i51__net2 vss 146.644e-18
c2395 n2__i28__i51__net3 vss 87.6825e-18
c2396 n7__net3 vss 67.6319e-18
c2397 n233__rst vss 136.595e-18
c2398 n9__i29__net34 vss 162.632e-18
c2399 n239__clk100m_b vss 147.434e-18
c2400 n350__clk100m vss 195.107e-18
c2401 n351__clk100m vss 113.677e-18
c2402 n6__i28__i53__net3 vss 96.1739e-18
c2403 n6__net3 vss 207.033e-18
c2404 n230__rst vss 133.989e-18
c2405 n9__i28__net5 vss 76.7494e-18
c2406 n155__net23 vss 149.291e-18
c2407 n574__clk1pt6g vss 166.155e-18
c2408 n575__clk1pt6g vss 133.253e-18
c2409 n578__clk1pt6g vss 139.336e-18
c2410 n133__net29 vss 159.695e-18
c2411 n8__i29__net34 vss 16.3983e-18
c2412 n12__net34 vss 99.9726e-18
c2413 n141__rst_b vss 44.4168e-18
c2414 n5__net34 vss 124.573e-18
c2415 n572__clk1pt6g vss 289.598e-18
c2416 n73__net22 vss 204.57e-18
c2417 n10__i33__i18__net1 vss 116.318e-18
c2418 n348__clk100m vss 143.662e-18
c2419 n13__i28__net11 vss 100.366e-18
c2420 n227__rst vss 157.613e-18
c2421 n6__i28__i53__net2 vss 164.535e-18
c2422 n4__i28__i53__net3 vss 111.548e-18
c2423 n226__rst vss 152.448e-18
c2424 n4__net3 vss 127.906e-18
c2425 n138__vdd vss 157.148e-18
c2426 n133__vdd vss 111.586e-18
c2427 n37__net5 vss 172.077e-18
c2428 n236__clk100m_b vss 81.3237e-18
c2429 n3__i29__net34 vss 82.0952e-18
c2430 n3__net34 vss 117.867e-18
c2431 n347__clk100m vss 265.891e-18
c2432 n234__clk100m_b vss 143.914e-18
c2433 n151__net23 vss 121.851e-18
c2434 n130__net29 vss 177.884e-18
c2435 n571__clk1pt6g vss 95.9914e-18
c2436 n563__clk1pt6g vss 197.655e-18
c2437 n149__net23 vss 107.471e-18
c2438 n562__clk1pt6g vss 43.7278e-18
c2439 n2__i28__i53__net3 vss 105.578e-18
c2440 n2__i28__i53__net2 vss 148.503e-18
c2441 n5__out11 vss 54.8243e-18
c2442 n28__net5 vss 149.423e-18
c2443 n131__vdd vss 154.462e-18
c2444 n26__net5 vss 224.989e-18
c2445 n11__i28__net19 vss 15.2619e-18
c2446 n34__i28__net13 vss 98.5754e-18
c2447 n7__net4 vss 111.288e-18
c2448 n222__rst vss 136.63e-18
c2449 n9__i29__net6 vss 162.632e-18
c2450 n233__clk100m_b vss 147.09e-18
c2451 n343__clk100m vss 193.058e-18
c2452 n344__clk100m vss 88.3115e-18
c2453 n6__i28__i53__net5 vss 96.1273e-18
c2454 n6__net4 vss 207.033e-18
c2455 n219__rst vss 134.054e-18
c2456 n146__net23 vss 149.291e-18
c2457 n551__clk1pt6g vss 166.116e-18
c2458 n552__clk1pt6g vss 81.2164e-18
c2459 n555__clk1pt6g vss 137.234e-18
c2460 n125__net29 vss 159.695e-18
c2461 n8__i29__net6 vss 16.3983e-18
c2462 n13__net33 vss 99.9726e-18
c2463 n134__rst_b vss 129.683e-18
c2464 n72__net22 vss 200.492e-18
c2465 n550__clk1pt6g vss 312.554e-18
c2466 n6__net33 vss 65.9267e-18
c2467 n10__i33__i17__net1 vss 202.295e-18
c2468 n6__i28__i72__net5 vss 75.8329e-18
c2469 n338__clk100m vss 143.787e-18
c2470 n7__i28__i53__net4 vss 99.2307e-18
c2471 n4__i28__i53__net5 vss 73.0577e-18
c2472 n216__rst vss 157.613e-18
c2473 n215__rst vss 152.551e-18
c2474 n4__net4 vss 127.907e-18
c2475 n128__vdd vss 157.269e-18
c2476 n123__vdd vss 111.586e-18
c2477 n23__net6 vss 172.077e-18
c2478 n229__clk100m_b vss 80.955e-18
c2479 n3__i29__net6 vss 82.0952e-18
c2480 n3__net33 vss 117.867e-18
c2481 n337__clk100m vss 263.053e-18
c2482 n225__clk100m_b vss 143.916e-18
c2483 n142__net23 vss 121.825e-18
c2484 n122__net29 vss 107.521e-18
c2485 n548__clk1pt6g vss 95.9988e-18
c2486 n69__net22 vss 75.557e-18
c2487 n7__i28__i72__net4 vss 98.2678e-18
c2488 n4__i28__i72__net5 vss 83.2979e-18
c2489 n542__clk1pt6g vss 198.05e-18
c2490 n140__net23 vss 107.537e-18
c2491 n2__i28__i53__net4 vss 82.6957e-18
c2492 n2__i28__i53__net5 vss 71.0601e-18
c2493 n5__out10 vss 54.8114e-18
c2494 n37__i28__net12 vss 212.531e-18
c2495 n19__i28__net26 vss 315.02e-18
c2496 n16__net6 vss 149.423e-18
c2497 n121__vdd vss 154.462e-18
c2498 n14__net6 vss 225.08e-18
c2499 n21__net5 vss 67.6319e-18
c2500 n2__i28__i72__net4 vss 83.2724e-18
c2501 n2__i28__i72__net5 vss 93.2355e-18
c2502 n211__rst vss 136.595e-18
c2503 n9__i29__net12 vss 162.597e-18
c2504 n9__i28__i50__net1 vss 208.27e-18
c2505 n14__i28__i50__net1 vss 201.262e-18
c2506 n222__clk100m_b vss 147.09e-18
c2507 n330__clk100m vss 193.532e-18
c2508 n331__clk100m vss 114.182e-18
c2509 n20__net5 vss 207.033e-18
c2510 n208__rst vss 134.083e-18
c2511 n137__net23 vss 148.191e-18
c2512 n533__clk1pt6g vss 166.154e-18
c2513 n532__clk1pt6g vss 93.593e-18
c2514 n540__clk1pt6g vss 142.691e-18
c2515 n118__net29 vss 159.594e-18
c2516 n8__i29__net12 vss 16.3983e-18
c2517 n13__net32 vss 99.9726e-18
c2518 n129__rst_b vss 44.4168e-18
c2519 n25__i28__net7 vss 49.5744e-18
c2520 n5__net32 vss 124.573e-18
c2521 n6__i28__i72__net3 vss 110.261e-18
c2522 n10__i33__i22__net1 vss 116.318e-18
c2523 n325__clk100m vss 143.897e-18
c2524 n201__rst vss 157.613e-18
c2525 n24__i28__net7 vss 154.377e-18
c2526 n199__rst vss 152.448e-18
c2527 n18__net5 vss 127.906e-18
c2528 n118__vdd vss 157.269e-18
c2529 n113__vdd vss 136.402e-18
c2530 n23__net7 vss 172.077e-18
c2531 n215__clk100m_b vss 81.0045e-18
c2532 n3__i29__net12 vss 82.0952e-18
c2533 n3__net32 vss 85.2764e-18
c2534 n322__clk100m vss 263.237e-18
c2535 n211__clk100m_b vss 143.916e-18
c2536 n133__net23 vss 121.292e-18
c2537 n113__net29 vss 107.752e-18
c2538 n522__clk1pt6g vss 64.8368e-18
c2539 n6__i28__i72__net2 vss 163.233e-18
c2540 n4__i28__i72__net3 vss 117.387e-18
c2541 n516__clk1pt6g vss 197.23e-18
c2542 n131__net23 vss 112.941e-18
c2543 n17__i28__net26 vss 297.835e-18
c2544 n36__i28__net12 vss 208.454e-18
c2545 n4__i33__i22__net1 vss 91.6461e-18
c2546 n5__out9 vss 54.8408e-18
c2547 n16__net7 vss 149.423e-18
c2548 n111__vdd vss 154.462e-18
c2549 n14__net7 vss 225.089e-18
c2550 n2__i28__i72__net2 vss 147.179e-18
c2551 n2__i28__i72__net3 vss 86.9943e-18
c2552 n7__net6 vss 67.6319e-18
c2553 n195__rst vss 136.595e-18
c2554 n9__i29__net25 vss 162.556e-18
c2555 n8__i28__i50__net1 vss 198.481e-18
c2556 n16__i28__net2 vss 71.2714e-18
c2557 n18__i28__net2 vss 69.9188e-18
c2558 n208__clk100m_b vss 147.09e-18
c2559 n315__clk100m vss 193.532e-18
c2560 n316__clk100m vss 88.3115e-18
c2561 n9__i28__net19 vss 77.5484e-18
c2562 n6__net6 vss 207.033e-18
c2563 n192__rst vss 134.083e-18
c2564 n128__net23 vss 148.191e-18
c2565 n507__clk1pt6g vss 166.406e-18
c2566 n506__clk1pt6g vss 142.518e-18
c2567 n514__clk1pt6g vss 139.05e-18
c2568 n109__net29 vss 159.695e-18
c2569 n8__i29__net25 vss 16.3983e-18
c2570 n13__net31 vss 99.9726e-18
c2571 n119__rst_b vss 129.683e-18
c2572 n5__net31 vss 124.573e-18
c2573 n10__i33__i19__net1 vss 116.318e-18
c2574 n310__clk100m vss 143.897e-18
c2575 n21__i28__net7 vss 126.991e-18
c2576 n13__i28__net26 vss 118.386e-18
c2577 n185__rst vss 157.613e-18
c2578 n183__rst vss 152.448e-18
c2579 n4__net6 vss 127.906e-18
c2580 n108__vdd vss 157.269e-18
c2581 n103__vdd vss 111.586e-18
c2582 n23__net8 vss 172.077e-18
c2583 n201__clk100m_b vss 81.0045e-18
c2584 n12__i28__net2 vss 73.9411e-18
c2585 n14__i28__net2 vss 61.5536e-18
c2586 n7__i28__i50__net1 vss 259.754e-18
c2587 n3__i29__net25 vss 82.0952e-18
c2588 n3__net31 vss 85.2764e-18
c2589 n307__clk100m vss 263.237e-18
c2590 n197__clk100m_b vss 143.967e-18
c2591 n124__net23 vss 121.376e-18
c2592 n104__net29 vss 178.009e-18
c2593 n498__clk1pt6g vss 95.9988e-18
c2594 n492__clk1pt6g vss 198.256e-18
c2595 n122__net23 vss 104.02e-18
c2596 n4__i33__i19__net1 vss 91.6461e-18
c2597 n5__out8 vss 54.6896e-18
c2598 n16__net8 vss 149.423e-18
c2599 n101__vdd vss 154.462e-18
c2600 n14__net8 vss 234.338e-18
c2601 n11__i28__net17 vss 15.3196e-18
c2602 n34__i28__net12 vss 85.7927e-18
c2603 n7__net7 vss 67.6319e-18
c2604 n10__i28__net2 vss 99.38e-18
c2605 n179__rst vss 136.595e-18
c2606 n9__i29__net23 vss 162.632e-18
c2607 n194__clk100m_b vss 147.09e-18
c2608 n299__clk100m vss 193.451e-18
c2609 n300__clk100m vss 88.5007e-18
c2610 n6__net7 vss 207.033e-18
c2611 n176__rst vss 134.083e-18
c2612 n119__net23 vss 147.994e-18
c2613 n483__clk1pt6g vss 166.357e-18
c2614 n482__clk1pt6g vss 134.429e-18
c2615 n485__clk1pt6g vss 138.045e-18
c2616 n98__net29 vss 159.695e-18
c2617 n8__i29__net23 vss 16.3983e-18
c2618 n13__net30 vss 157.571e-18
c2619 n109__rst_b vss 44.4168e-18
c2620 n5__net30 vss 65.9267e-18
c2621 n10__i33__i21__net1 vss 202.295e-18
c2622 n5__i28__i71__net5 vss 75.43e-18
c2623 n294__clk100m vss 143.924e-18
c2624 n169__rst vss 157.613e-18
c2625 n167__rst vss 152.448e-18
c2626 n4__net7 vss 170.255e-18
c2627 n98__vdd vss 157.934e-18
c2628 n93__vdd vss 111.586e-18
c2629 n23__net9 vss 172.077e-18
c2630 n187__clk100m_b vss 81.0045e-18
c2631 n3__i29__net23 vss 82.0952e-18
c2632 n3__net30 vss 85.2764e-18
c2633 n291__clk100m vss 262.856e-18
c2634 n181__clk100m_b vss 135.521e-18
c2635 n115__net23 vss 120.024e-18
c2636 n95__net29 vss 192.478e-18
c2637 n472__clk1pt6g vss 95.9988e-18
c2638 n7__i28__i71__net4 vss 97.89e-18
c2639 n4__i28__i71__net5 vss 83.6968e-18
c2640 n466__clk1pt6g vss 197.866e-18
c2641 n113__net23 vss 111.955e-18
c2642 n5__out7 vss 54.8948e-18
c2643 n37__i28__net3 vss 212.271e-18
c2644 n19__i28__net23 vss 314.804e-18
c2645 n16__net9 vss 149.423e-18
c2646 n91__vdd vss 153.308e-18
c2647 n14__net9 vss 228.855e-18
c2648 n7__net8 vss 67.6319e-18
c2649 n2__i28__i71__net4 vss 83.4075e-18
c2650 n2__i28__i71__net5 vss 93.1841e-18
c2651 n163__rst vss 136.595e-18
c2652 n9__i29__net14 vss 162.911e-18
c2653 n178__clk100m_b vss 147.09e-18
c2654 n284__clk100m vss 193.532e-18
c2655 n285__clk100m vss 114.154e-18
c2656 n6__net8 vss 207.033e-18
c2657 n160__rst vss 134.083e-18
c2658 n110__net23 vss 147.227e-18
c2659 n457__clk1pt6g vss 166.528e-18
c2660 n456__clk1pt6g vss 139.714e-18
c2661 n459__clk1pt6g vss 142.67e-18
c2662 n89__net29 vss 159.576e-18
c2663 n8__i29__net14 vss 77.7227e-18
c2664 n13__net43 vss 99.9726e-18
c2665 n99__rst_b vss 44.4168e-18
c2666 n5__net43 vss 124.573e-18
c2667 n6__i28__i71__net3 vss 109.945e-18
c2668 n10__i33__i20__net1 vss 116.318e-18
c2669 n279__clk100m vss 143.858e-18
c2670 n153__rst vss 157.613e-18
c2671 n151__rst vss 152.448e-18
c2672 n4__net8 vss 127.906e-18
c2673 n88__vdd vss 157.269e-18
c2674 n83__vdd vss 111.586e-18
c2675 n23__net10 vss 172.077e-18
c2676 n171__clk100m_b vss 81.0045e-18
c2677 n3__i29__net14 vss 82.0952e-18
c2678 n3__net43 vss 117.862e-18
c2679 n276__clk100m vss 263.237e-18
c2680 n167__clk100m_b vss 143.916e-18
c2681 n106__net23 vss 120.041e-18
c2682 n6__i28__i71__net2 vss 165.028e-18
c2683 n4__i28__i71__net3 vss 117.137e-18
c2684 n86__net29 vss 107.743e-18
c2685 n448__clk1pt6g vss 95.9988e-18
c2686 n442__clk1pt6g vss 198.111e-18
c2687 n104__net23 vss 112.28e-18
c2688 n17__i28__net23 vss 297.793e-18
c2689 n36__i28__net3 vss 208.6e-18
c2690 n5__out6 vss 54.8382e-18
c2691 n16__net10 vss 149.423e-18
c2692 n81__vdd vss 154.462e-18
c2693 n14__net10 vss 225.089e-18
c2694 n2__i28__i71__net2 vss 147.156e-18
c2695 n2__i28__i71__net3 vss 87.7405e-18
c2696 n7__net9 vss 67.6319e-18
c2697 n147__rst vss 136.595e-18
c2698 n9__i29__net21 vss 162.705e-18
c2699 n164__clk100m_b vss 147.09e-18
c2700 n269__clk100m vss 193.532e-18
c2701 n270__clk100m vss 88.3115e-18
c2702 n9__i28__net17 vss 38.7974e-18
c2703 n6__net9 vss 206.034e-18
c2704 n144__rst vss 134.083e-18
c2705 n101__net23 vss 147.994e-18
c2706 n431__clk1pt6g vss 166.32e-18
c2707 n432__clk1pt6g vss 89.7292e-18
c2708 n435__clk1pt6g vss 138.99e-18
c2709 n80__net29 vss 159.695e-18
c2710 n8__i29__net21 vss 16.3983e-18
c2711 n13__net42 vss 99.9726e-18
c2712 n89__rst_b vss 129.683e-18
c2713 n5__net42 vss 124.573e-18
c2714 n10__i33__i30__net1 vss 116.318e-18
c2715 n264__clk100m vss 143.924e-18
c2716 n13__i28__net23 vss 99.8679e-18
c2717 n137__rst vss 157.613e-18
c2718 n135__rst vss 152.448e-18
c2719 n4__net9 vss 127.906e-18
c2720 n78__vdd vss 157.269e-18
c2721 n73__vdd vss 111.586e-18
c2722 n23__net11 vss 172.077e-18
c2723 n157__clk100m_b vss 81.0045e-18
c2724 n3__i29__net21 vss 82.0952e-18
c2725 n3__net42 vss 117.867e-18
c2726 n261__clk100m vss 263.237e-18
c2727 n153__clk100m_b vss 143.916e-18
c2728 n97__net23 vss 119.93e-18
c2729 n77__net29 vss 177.356e-18
c2730 n429__clk1pt6g vss 95.9988e-18
c2731 n423__clk1pt6g vss 197.937e-18
c2732 n95__net23 vss 112.245e-18
c2733 n5__out5 vss 54.6896e-18
c2734 n16__net11 vss 149.423e-18
c2735 n71__vdd vss 154.462e-18
c2736 n14__net11 vss 225.089e-18
c2737 n11__i28__net15 vss 15.5366e-18
c2738 n34__i28__net3 vss 102.471e-18
c2739 n7__net10 vss 67.6319e-18
c2740 n131__rst vss 136.595e-18
c2741 n9__i29__net29 vss 162.654e-18
c2742 n150__clk100m_b vss 147.09e-18
c2743 n230__clk100m vss 193.532e-18
c2744 n231__clk100m vss 114.182e-18
c2745 n6__net10 vss 207.033e-18
c2746 n128__rst vss 134.083e-18
c2747 n92__net23 vss 147.179e-18
c2748 n414__clk1pt6g vss 166.469e-18
c2749 n413__clk1pt6g vss 89.1971e-18
c2750 n416__clk1pt6g vss 137.184e-18
c2751 n71__net29 vss 159.695e-18
c2752 n8__i29__net29 vss 16.3983e-18
c2753 n13__net41 vss 99.9726e-18
c2754 n79__rst_b vss 44.4168e-18
c2755 n5__net41 vss 65.9267e-18
c2756 n10__i33__i23__net1 vss 116.318e-18
c2757 n5__i28__i70__net5 vss 74.308e-18
c2758 n225__clk100m vss 143.858e-18
c2759 n121__rst vss 157.613e-18
c2760 n119__rst vss 152.448e-18
c2761 n4__net10 vss 127.906e-18
c2762 n68__vdd vss 157.269e-18
c2763 n63__vdd vss 111.586e-18
c2764 n23__net12 vss 172.077e-18
c2765 n143__clk100m_b vss 81.0045e-18
c2766 n3__i29__net29 vss 168.435e-18
c2767 n3__net41 vss 85.2717e-18
c2768 n222__clk100m vss 263.237e-18
c2769 n139__clk100m_b vss 89.9544e-18
c2770 n88__net23 vss 119.97e-18
c2771 n68__net29 vss 192.225e-18
c2772 n410__clk1pt6g vss 95.9988e-18
c2773 n7__i28__i70__net4 vss 98.7824e-18
c2774 n4__i28__i70__net5 vss 84.3114e-18
c2775 n404__clk1pt6g vss 197.737e-18
c2776 n86__net23 vss 112.346e-18
c2777 n37__i28__net9 vss 212.649e-18
c2778 n19__i28__net20 vss 313.734e-18
c2779 n5__out4 vss 54.8282e-18
c2780 n16__net12 vss 149.423e-18
c2781 n61__vdd vss 154.462e-18
c2782 n14__net12 vss 225.089e-18
c2783 n2__i28__i70__net4 vss 84.4849e-18
c2784 n2__i28__i70__net5 vss 93.2583e-18
c2785 n7__net11 vss 67.6319e-18
c2786 n115__rst vss 136.595e-18
c2787 n9__i29__net16 vss 162.67e-18
c2788 n136__clk100m_b vss 147.09e-18
c2789 n215__clk100m vss 193.532e-18
c2790 n216__clk100m vss 114.182e-18
c2791 n6__net11 vss 207.033e-18
c2792 n112__rst vss 134.083e-18
c2793 n83__net23 vss 147.184e-18
c2794 n395__clk1pt6g vss 166.447e-18
c2795 n394__clk1pt6g vss 139.969e-18
c2796 n397__clk1pt6g vss 145.816e-18
c2797 n62__net29 vss 159.626e-18
c2798 n8__i29__net16 vss 16.3983e-18
c2799 n13__net40 vss 99.9726e-18
c2800 n69__rst_b vss 129.683e-18
c2801 n5__net40 vss 124.573e-18
c2802 n6__i28__i70__net3 vss 112.856e-18
c2803 n10__i33__i25__net1 vss 116.318e-18
c2804 n210__clk100m vss 143.859e-18
c2805 n105__rst vss 157.613e-18
c2806 n103__rst vss 152.448e-18
c2807 n4__net11 vss 127.906e-18
c2808 n58__vdd vss 157.269e-18
c2809 n53__vdd vss 111.586e-18
c2810 n23__net13 vss 172.077e-18
c2811 n129__clk100m_b vss 81.0045e-18
c2812 n3__i29__net16 vss 82.0952e-18
c2813 n3__net40 vss 85.2764e-18
c2814 n207__clk100m vss 263.237e-18
c2815 n125__clk100m_b vss 143.916e-18
c2816 n6__i28__i70__net2 vss 165.402e-18
c2817 n4__i28__i70__net3 vss 117.52e-18
c2818 n79__net23 vss 120.088e-18
c2819 n59__net29 vss 192.224e-18
c2820 n391__clk1pt6g vss 96.0062e-18
c2821 n385__clk1pt6g vss 197.812e-18
c2822 n77__net23 vss 112.197e-18
c2823 n17__i28__net20 vss 298.704e-18
c2824 n36__i28__net9 vss 209.432e-18
c2825 n4__i33__i25__net1 vss 132.771e-18
c2826 n5__out3 vss 54.6896e-18
c2827 n16__net13 vss 149.423e-18
c2828 n51__vdd vss 154.462e-18
c2829 n2__i28__i70__net2 vss 146.352e-18
c2830 n14__net13 vss 225.089e-18
c2831 n2__i28__i70__net3 vss 87.8493e-18
c2832 n7__net12 vss 67.6319e-18
c2833 n99__rst vss 136.595e-18
c2834 n9__i29__net9 vss 162.555e-18
c2835 n122__clk100m_b vss 147.09e-18
c2836 n198__clk100m vss 193.532e-18
c2837 n199__clk100m vss 114.182e-18
c2838 n203__clk100m vss 49.8847e-18
c2839 n9__i28__net15 vss 73.9181e-18
c2840 n6__net12 vss 207.033e-18
c2841 n96__rst vss 134.083e-18
c2842 n74__net23 vss 147.384e-18
c2843 n376__clk1pt6g vss 166.479e-18
c2844 n375__clk1pt6g vss 139.202e-18
c2845 n378__clk1pt6g vss 138.514e-18
c2846 n53__net29 vss 159.695e-18
c2847 n8__i29__net9 vss 16.3983e-18
c2848 n13__net39 vss 158.026e-18
c2849 n59__rst_b vss 44.4168e-18
c2850 n5__net39 vss 124.573e-18
c2851 n10__i33__i24__net1 vss 116.318e-18
c2852 n193__clk100m vss 143.859e-18
c2853 n13__i28__net20 vss 113.281e-18
c2854 n89__rst vss 157.613e-18
c2855 n87__rst vss 152.448e-18
c2856 n4__net12 vss 127.906e-18
c2857 n48__vdd vss 157.269e-18
c2858 n43__vdd vss 111.585e-18
c2859 n35__net14 vss 172.077e-18
c2860 n91__clk100m_b vss 81.0045e-18
c2861 n3__i29__net9 vss 82.0952e-18
c2862 n3__net39 vss 85.2764e-18
c2863 n190__clk100m vss 263.563e-18
c2864 n87__clk100m_b vss 143.916e-18
c2865 n70__net23 vss 120.108e-18
c2866 n50__net29 vss 177.713e-18
c2867 n372__clk1pt6g vss 95.9988e-18
c2868 n366__clk1pt6g vss 197.958e-18
c2869 n68__net23 vss 112.038e-18
c2870 n5__out2 vss 54.6896e-18
c2871 n28__net14 vss 149.423e-18
c2872 n41__vdd vss 154.462e-18
c2873 n26__net14 vss 222.165e-18
c2874 n12__i28__net1 vss 15.5375e-18
c2875 n34__i28__net9 vss 102.284e-18
c2876 n7__net13 vss 67.6319e-18
c2877 n83__rst vss 136.595e-18
c2878 n9__i29__net19 vss 162.762e-18
c2879 n84__clk100m_b vss 147.036e-18
c2880 n185__clk100m vss 195.112e-18
c2881 n183__clk100m vss 114.105e-18
c2882 n6__net13 vss 207.033e-18
c2883 n80__rst vss 134.083e-18
c2884 n65__net23 vss 147.17e-18
c2885 n357__clk1pt6g vss 166.551e-18
c2886 n356__clk1pt6g vss 139.497e-18
c2887 n359__clk1pt6g vss 137.073e-18
c2888 n44__net29 vss 159.631e-18
c2889 n8__i29__net19 vss 16.3983e-18
c2890 n13__net38 vss 99.9726e-18
c2891 n49__rst_b vss 107.355e-18
c2892 n5__net38 vss 124.573e-18
c2893 n5__i28__i69__net5 vss 73.7103e-18
c2894 n10__i33__i29__net1 vss 116.318e-18
c2895 n178__clk100m vss 143.859e-18
c2896 n73__rst vss 157.613e-18
c2897 n71__rst vss 152.448e-18
c2898 n4__net13 vss 127.906e-18
c2899 n38__vdd vss 157.289e-18
c2900 n33__vdd vss 111.585e-18
c2901 n23__net15 vss 101.564e-18
c2902 n42__net22 vss 92.7966e-18
c2903 n77__clk100m_b vss 82.1983e-18
c2904 n3__i29__net19 vss 82.0952e-18
c2905 n3__net38 vss 117.874e-18
c2906 n175__clk100m vss 264.183e-18
c2907 n73__clk100m_b vss 143.868e-18
c2908 n61__net23 vss 119.971e-18
c2909 n41__net29 vss 192.222e-18
c2910 n353__clk1pt6g vss 95.9988e-18
c2911 n7__i28__i69__net4 vss 98.0563e-18
c2912 n4__i28__i69__net5 vss 84.9216e-18
c2913 n347__clk1pt6g vss 198.026e-18
c2914 n59__net23 vss 111.592e-18
c2915 n41__net22 vss 208.695e-18
c2916 n346__clk1pt6g vss 303.812e-18
c2917 n5__out1 vss 54.4734e-18
c2918 n16__net15 vss 149.423e-18
c2919 n31__vdd vss 154.462e-18
c2920 n14__net15 vss 225.23e-18
c2921 n2__i28__i69__net4 vss 82.5653e-18
c2922 n2__i28__i69__net5 vss 93.5738e-18
c2923 n67__rst vss 136.595e-18
c2924 n9__i29__net26 vss 162.897e-18
c2925 n70__clk100m_b vss 147.036e-18
c2926 n168__clk100m vss 194.665e-18
c2927 n169__clk100m vss 114.105e-18
c2928 n18__net14 vss 207.033e-18
c2929 n64__rst vss 134.083e-18
c2930 n56__net23 vss 147.892e-18
c2931 n337__clk1pt6g vss 168.395e-18
c2932 n336__clk1pt6g vss 89.9652e-18
c2933 n341__clk1pt6g vss 139.232e-18
c2934 n37__net29 vss 159.759e-18
c2935 n8__i29__net26 vss 16.8317e-18
c2936 n13__net19 vss 159.641e-18
c2937 n39__rst_b vss 44.4168e-18
c2938 n5__i28__i69__net3 vss 112.762e-18
c2939 n5__net19 vss 124.717e-18
c2940 n10__i33__i26__net1 vss 116.318e-18
c2941 n163__clk100m vss 145.186e-18
c2942 n57__rst vss 157.62e-18
c2943 n332__clk1pt6g vss 80.3884e-18
c2944 n55__rst vss 152.48e-18
c2945 n16__net14 vss 127.9e-18
c2946 n28__vdd vss 157.253e-18
c2947 n23__vdd vss 136.329e-18
c2948 n36__net16 vss 168.134e-18
c2949 n63__clk100m_b vss 82.1686e-18
c2950 n3__i29__net26 vss 80.0082e-18
c2951 n3__net19 vss 112.549e-18
c2952 n160__clk100m vss 266.238e-18
c2953 n59__clk100m_b vss 89.9544e-18
c2954 n6__i28__i69__net2 vss 161.928e-18
c2955 n4__i28__i69__net3 vss 119.28e-18
c2956 n50__net23 vss 121.06e-18
c2957 n32__net29 vss 231.218e-18
c2958 n330__clk1pt6g vss 67.459e-18
c2959 n323__clk1pt6g vss 232.423e-18
c2960 n48__net23 vss 116.566e-18
c2961 n327__clk1pt6g vss 300.461e-18
c2962 n40__net22 vss 207.153e-18
c2963 n1__out0 vss 61.0977e-18
c2964 n27__net16 vss 189.949e-18
c2965 n21__vdd vss 157.725e-18
c2966 n2__i28__i69__net2 vss 146.969e-18
c2967 n2__i28__i69__net3 vss 100.941e-18
c2968 n25__net16 vss 226.039e-18
c2969 n10__net18 vss 139.88e-18
c2970 n7__net15 vss 67.6085e-18
c2971 n51__rst vss 135.784e-18
c2972 n53__clk100m_b vss 145.986e-18
c2973 n153__clk100m vss 199.083e-18
c2974 n154__clk100m vss 134.345e-18
c2975 n54__clk100m_b vss 628.051e-18
c2976 n56__clk100m_b vss 355.365e-18
c2977 n9__i28__net1 vss 112.333e-18
c2978 n15__net29 vss 228.096e-18
c2979 n6__net15 vss 206.899e-18
c2980 n48__rst vss 134.109e-18
c2981 n29__rst_b vss 129.723e-18
c2982 n4__net18 vss 67.0643e-18
c2983 n10__i33__i28__net1 vss 202.368e-18
c2984 n41__rst vss 157.576e-18
c2985 n39__rst vss 152.45e-18
c2986 n4__net15 vss 128.027e-18
c2987 n18__vdd vss 121.966e-18
c2988 n11__vdd vss 115.436e-18
c2989 n23__net17 vss 167.192e-18
c2990 n46__clk100m_b vss 84.7132e-18
c2991 n30__net23 vss 35.8076e-18
c2992 n147__clk100m vss 267.373e-18
c2993 n42__clk100m_b vss 89.6601e-18
c2994 n24__net22 vss 28.1973e-18
c2995 n15__net17 vss 133.482e-18
c2996 n9__vdd vss 182.363e-18
c2997 n17__vdd vss 83.5094e-18
c2998 n13__net17 vss 188.906e-18
c2999 n20__net16 vss 110.451e-18
c3000 n35__rst vss 134.62e-18
c3001 n39__clk100m_b vss 142.989e-18
c3002 n35__clk100m vss 196.111e-18
c3003 n34__clk100m vss 132.117e-18
c3004 n4__vdd vss 94.9952e-18
c3005 n19__net16 vss 207.184e-18
c3006 n32__rst vss 132.248e-18
c3007 n19__rst_b vss 107.935e-18
c3008 n10__i33__i27__net1 vss 205.782e-18
c3009 n25__rst vss 164.073e-18
c3010 n23__rst vss 149.876e-18
c3011 n17__net16 vss 127.533e-18
c3012 n32__clk100m_b vss 84.7474e-18
c3013 n27__clk100m vss 259.892e-18
c3014 n28__clk100m_b vss 142.659e-18
c3015 n302__clk1pt6g vss 88.9318e-18
c3016 n4__i33__i27__net1 vss 66.3097e-18
c3017 n15__i33__xor1 vss 66.4957e-18
c3018 n14__i33__i56__net1 vss 36.7078e-18
c3019 n15__i33__xor2 vss 79.3603e-18
c3020 n3__i33__d0 vss 1.26661e-15
c3021 n10__i33__i56__net1 vss 73.7666e-18
c3022 n14__i33__xor2 vss 162.871e-18
c3023 n6__i33__i56__net2 vss 98.8063e-18
c3024 n1__vdd vss 47.4872e-18
c3025 n8__i33__i56__net1 vss 76.8171e-18
c3026 n2__i33__i56__net2 vss 84.5842e-18
c3027 n10__i33__xor2 vss 305.273e-18
c3028 n12__net16 vss 72.6445e-18
c3029 n11__i33__xor1 vss 109.994e-18
c3030 n282__clk1pt6g vss 74.2861e-18
c3031 n283__clk1pt6g vss 68.3706e-18
c3032 n6__i33__i57__net2 vss 36.6617e-18
c3033 n10__net14 vss 111.143e-18
c3034 n15__i33__i57__net1 vss 80.7682e-18
c3035 n6__i33__i58__net2 vss 36.1369e-18
c3036 n2__i33__i57__net2 vss 100.763e-18
c3037 n11__net17 vss 307.387e-18
c3038 n13__i33__i57__net1 vss 98.7291e-18
c3039 n15__i33__i58__net1 vss 76.0683e-18
c3040 n10__net17 vss 179.355e-18
c3041 n7__i33__i57__net1 vss 71.3624e-18
c3042 n6__net16 vss 89.1635e-18
c3043 n2__i33__i58__net2 vss 101.075e-18
c3044 n14__net5 vss 106.978e-18
c3045 n13__i33__i58__net1 vss 63.324e-18
c3046 n5__i33__xor1 vss 31.6381e-18
c3047 n10__net5 vss 153.916e-18
c3048 n5__net14 vss 155.737e-18
c3049 n343__vdd vss 20.8418e-15
c3050 n13__net21 vss 60.4602e-18
c3051 n5__net1 vss 50.9115e-18
c3052 n5__net28 vss 50.7979e-18
c3053 n10__net25 vss 34.8838e-18
c3054 n6__i40__i42__x vss 70.8738e-18
c3055 n411__vdd vss 399.713e-18
c3056 n300__vdd vss 56.4419e-18
c3057 n6__i29__i161__x vss 83.1707e-18
c3058 n436__vdd vss 1.3324e-15
c3059 n344__vdd vss 61.2238e-18
c3060 n11__net20 vss 3.09579e-21
c3061 n11__net21 vss 75.6662e-18
c3062 n8__net28 vss 81.8399e-18
c3063 n11__net25 vss 41.3731e-18
c3064 n4__i40__i42__x vss 73.5886e-18
c3065 n299__vdd vss 32.8306e-18
c3066 n637__vdd vss 51.8182e-18
c3067 n345__vdd vss 82.6117e-18
c3068 n7__i29__i161__x vss 97.4166e-18
c3069 n641__vdd vss 125.411e-18
c3070 n5__out15 vss 69.5924e-18
c3071 n6__net1 vss 188.411e-18
c3072 n635__vdd vss 60.832e-18
c3073 n346__vdd vss 78.6768e-18
c3074 n644__vdd vss 110.801e-18
c3075 n10__i29__net7 vss 177.233e-21
c3076 n8__out15 vss 48.0807e-18
c3077 n4__net1 vss 104.053e-18
c3078 n12__i29__net7 vss 103.066e-18
c3079 n646__vdd vss 62.9175e-18
c3080 n4__i40__i43__x vss 71.5354e-18
c3081 n12__net24 vss 103.822e-18
c3082 n632__vdd vss 51.2988e-18
c3083 n5__i29__net8 vss 81.6057e-18
c3084 n347__vdd vss 82.1478e-18
c3085 n6__i40__i43__x vss 70.935e-18
c3086 n11__net24 vss 61.6749e-18
c3087 n279__vdd vss 28.8056e-18
c3088 n6__i29__net8 vss 53.1272e-18
c3089 n6__i29__i144__x vss 83.576e-18
c3090 n6__net37 vss 52.4379e-18
c3091 n8__out14 vss 48.0308e-18
c3092 n342__vdd vss 321.733e-18
c3093 n212__vdd vss 1.85369e-15
c3094 n648__vdd vss 66.7893e-18
c3095 n7__i29__i144__x vss 98.8206e-18
c3096 n7__net37 vss 68.1488e-18
c3097 n5__out14 vss 69.8046e-18
c3098 n605__vdd vss 80.5407e-18
c3099 n630__vdd vss 60.6706e-18
c3100 n348__vdd vss 78.339e-18
c3101 n11__net2 vss 60.7521e-18
c3102 n13__i28__net5 vss 63.2299e-18
c3103 n12__i29__net13 vss 103.248e-18
c3104 n11__i33__d0 vss 4.50419e-21
c3105 n9__net2 vss 75.6262e-18
c3106 n14__i28__net5 vss 104.477e-18
c3107 n10__i29__net13 vss 177.233e-21
c3108 n652__vdd vss 67.5637e-18
c3109 n249__rst vss 272.369e-21
c3110 n601__vdd vss 108.678e-18
c3111 n11__i28__i52__net2 vss 91.7895e-18
c3112 n4__i40__i44__x vss 71.5218e-18
c3113 n211__vdd vss 52.7385e-18
c3114 n10__i33__i0__net1 vss 89.7878e-21
c3115 n13__i28__i51__net4 vss 62.0883e-18
c3116 n627__vdd vss 51.2988e-18
c3117 n654__vdd vss 118.304e-18
c3118 n5__i29__net4 vss 81.8256e-18
c3119 n349__vdd vss 82.0269e-18
c3120 n5__i28__i52__net3 vss 39.8398e-18
c3121 n6__i40__i44__x vss 70.9632e-18
c3122 n8__i33__i0__net1 vss 76.504e-18
c3123 n280__vdd vss 29.5706e-18
c3124 n5__i28__i51__net5 vss 37.8791e-18
c3125 n6__i29__net4 vss 53.0898e-18
c3126 n6__i33__i0__x vss 75.5393e-18
c3127 n19__i28__net6 vss 71.2753e-18
c3128 n3__i28__i52__net3 vss 50.4761e-18
c3129 n6__i29__i143__x vss 83.7489e-18
c3130 n3__i28__i51__net5 vss 46.5933e-18
c3131 n6__net36 vss 52.4798e-18
c3132 n11__i28__i52__x vss 68.8847e-18
c3133 n8__out13 vss 48.0308e-18
c3134 n6__i33__d0 vss 126.152e-21
c3135 n7__i33__i0__x vss 107.842e-18
c3136 n20__i28__net6 vss 111.954e-18
c3137 n7__i28__i52__net2 vss 244.044e-21
c3138 n7__i29__i143__x vss 98.8206e-18
c3139 n8__i28__i51__net4 vss 65.1825e-18
c3140 n7__net36 vss 70.504e-18
c3141 n9__i28__i52__x vss 107.987e-18
c3142 n5__out13 vss 69.9381e-18
c3143 n213__vdd vss 58.8682e-18
c3144 n596__vdd vss 116.812e-18
c3145 n3__i28__i52__net2 vss 758.754e-24
c3146 n625__vdd vss 60.6676e-18
c3147 n350__vdd vss 78.3895e-18
c3148 n3__i28__i51__net4 vss 60.1375e-18
c3149 n10__net3 vss 86.3285e-18
c3150 n656__vdd vss 110.036e-18
c3151 n10__i29__net18 vss 302.394e-21
c3152 n590__vdd vss 107.978e-18
c3153 n240__rst vss 1.68052e-21
c3154 n13__i28__i52__net4 vss 60.8609e-18
c3155 n12__net3 vss 69.3807e-18
c3156 n12__i29__net18 vss 103.753e-18
c3157 n5__i28__i52__net5 vss 37.2146e-18
c3158 n4__i40__i45__x vss 71.9575e-18
c3159 n214__vdd vss 52.8088e-18
c3160 n11__i33__i16__net1 vss 89.7878e-21
c3161 n11__i28__i51__net2 vss 214.756e-21
c3162 n658__vdd vss 116.892e-18
c3163 n622__vdd vss 51.2988e-18
c3164 n5__i29__net3 vss 81.8256e-18
c3165 n351__vdd vss 81.9633e-18
c3166 n6__i40__i45__x vss 70.9937e-18
c3167 n9__i33__i16__net1 vss 76.3395e-18
c3168 n5__i28__i51__net3 vss 35.142e-18
c3169 n281__vdd vss 29.5691e-18
c3170 n6__i29__net3 vss 53.0898e-18
c3171 n10__i28__i51__x vss 67.5759e-18
c3172 n6__i33__i16__x vss 75.2674e-18
c3173 n3__i28__i52__net5 vss 46.3505e-18
c3174 n6__i29__i142__x vss 83.9581e-18
c3175 n3__i28__i51__net3 vss 50.3732e-18
c3176 n31__i28__net7 vss 72.2789e-18
c3177 n6__net35 vss 52.4798e-18
c3178 n8__out12 vss 48.0308e-18
c3179 n11__i28__i51__x vss 108.539e-18
c3180 n2__net2 vss 126.152e-21
c3181 n7__i33__i16__x vss 108.261e-18
c3182 n8__i28__i52__net4 vss 65.4849e-18
c3183 n7__i29__i142__x vss 98.8242e-18
c3184 n7__i28__i51__net2 vss 42.0952e-21
c3185 n29__i28__net7 vss 121.378e-18
c3186 n7__net35 vss 70.504e-18
c3187 n6__out12 vss 69.8725e-18
c3188 n215__vdd vss 58.8682e-18
c3189 n584__vdd vss 117.833e-18
c3190 n3__i28__i52__net4 vss 61.6378e-18
c3191 n620__vdd vss 60.6676e-18
c3192 n352__vdd vss 78.3895e-18
c3193 n3__i28__i51__net2 vss 134.132e-21
c3194 n13__net4 vss 86.3285e-18
c3195 n660__vdd vss 99.8729e-18
c3196 n10__i29__net34 vss 302.394e-21
c3197 n578__vdd vss 69.3321e-18
c3198 n11__i28__i53__net2 vss 397.427e-21
c3199 n231__rst vss 1.68052e-21
c3200 n15__net4 vss 69.3807e-18
c3201 n12__i29__net34 vss 103.979e-18
c3202 n5__i28__i53__net3 vss 39.447e-18
c3203 n4__i40__i46__x vss 71.798e-18
c3204 n216__vdd vss 52.8088e-18
c3205 n662__vdd vss 117.53e-18
c3206 n11__i33__i18__net1 vss 89.7878e-21
c3207 n579__vdd vss 62.2484e-18
c3208 n617__vdd vss 51.2988e-18
c3209 n5__i29__net2 vss 81.8256e-18
c3210 n353__vdd vss 82.0572e-18
c3211 n6__i40__i46__x vss 70.935e-18
c3212 n9__i33__i18__net1 vss 76.3395e-18
c3213 n282__vdd vss 29.5691e-18
c3214 n6__i29__net2 vss 53.0898e-18
c3215 n6__i33__i18__x vss 75.2674e-18
c3216 n3__i28__i53__net3 vss 52.1915e-18
c3217 n15__i28__net11 vss 66.0193e-18
c3218 n6__i29__i141__x vss 83.9745e-18
c3219 n11__i28__i53__x vss 67.3676e-18
c3220 n7__net34 vss 52.4798e-18
c3221 n8__out11 vss 48.0308e-18
c3222 n2__net3 vss 126.152e-21
c3223 n7__i33__i18__x vss 108.251e-18
c3224 n7__i28__i53__net2 vss 7.84966e-18
c3225 n16__i28__net11 vss 101.665e-18
c3226 n7__i29__i141__x vss 98.8242e-18
c3227 n9__i28__i53__x vss 112.491e-18
c3228 n571__vdd vss 62.656e-18
c3229 n8__net34 vss 70.504e-18
c3230 n6__out11 vss 69.1526e-18
c3231 n217__vdd vss 58.8682e-18
c3232 n3__i28__i53__net2 vss 91.3458e-21
c3233 n572__vdd vss 58.836e-18
c3234 n615__vdd vss 60.6676e-18
c3235 n354__vdd vss 78.3202e-18
c3236 n664__vdd vss 109.664e-18
c3237 n25__net5 vss 86.0755e-18
c3238 n14__i28__net19 vss 104.612e-18
c3239 n11__i29__net6 vss 302.394e-21
c3240 n13__i28__i53__net4 vss 61.0338e-18
c3241 n220__rst vss 1.68052e-21
c3242 n564__vdd vss 108.247e-18
c3243 n27__net5 vss 69.0491e-18
c3244 n13__i28__net19 vss 61.0362e-18
c3245 n13__i29__net6 vss 103.612e-18
c3246 n5__i28__i53__net5 vss 37.4027e-18
c3247 n4__i40__i47__x vss 71.5218e-18
c3248 n666__vdd vss 116.628e-18
c3249 n218__vdd vss 53.9016e-18
c3250 n11__i33__i17__net1 vss 89.7878e-21
c3251 n13__i28__i72__net4 vss 61.8589e-18
c3252 n612__vdd vss 51.2988e-18
c3253 n5__i29__net1 vss 81.8256e-18
c3254 n355__vdd vss 81.9633e-18
c3255 n8__i28__i53__net4 vss 65.5467e-18
c3256 n6__i40__i47__x vss 70.9632e-18
c3257 n9__i33__i17__net1 vss 76.3395e-18
c3258 n5__i28__i72__net5 vss 37.8791e-18
c3259 n283__vdd vss 29.5691e-18
c3260 n6__i29__net1 vss 53.0898e-18
c3261 n3__i28__i53__net5 vss 46.6848e-18
c3262 n6__i33__i17__x vss 75.2674e-18
c3263 n32__i28__net13 vss 71.244e-18
c3264 n6__i29__i140__x vss 83.899e-18
c3265 n19__i28__net8 vss 70.1474e-18
c3266 n3__i28__i72__net5 vss 46.5492e-18
c3267 n8__net33 vss 52.4798e-18
c3268 n8__out10 vss 48.0308e-18
c3269 n2__net4 vss 126.152e-21
c3270 n7__i33__i17__x vss 109.886e-18
c3271 n33__i28__net13 vss 112.858e-18
c3272 n7__i29__i140__x vss 98.8242e-18
c3273 n17__i28__net8 vss 122.023e-18
c3274 n8__i28__i72__net4 vss 65.398e-18
c3275 n9__net33 vss 70.504e-18
c3276 n6__out10 vss 69.9381e-18
c3277 n3__i28__i53__net4 vss 60.4284e-18
c3278 n219__vdd vss 59.2645e-18
c3279 n558__vdd vss 116.798e-18
c3280 n610__vdd vss 60.6706e-18
c3281 n356__vdd vss 78.3895e-18
c3282 n668__vdd vss 102.792e-18
c3283 n3__i28__i72__net4 vss 60.277e-18
c3284 n13__net6 vss 86.5622e-18
c3285 n11__i29__net12 vss 302.394e-21
c3286 n10__i28__i50__net1 vss 112.894e-18
c3287 n552__vdd vss 107.994e-18
c3288 n209__rst vss 1.68052e-21
c3289 n15__net6 vss 69.0491e-18
c3290 n13__i29__net12 vss 103.711e-18
c3291 n12__i28__i50__net1 vss 99.5588e-18
c3292 n4__i40__i48__x vss 71.9589e-18
c3293 n670__vdd vss 119.914e-18
c3294 n220__vdd vss 53.9061e-18
c3295 n11__i28__i72__net2 vss 215.755e-21
c3296 n11__i33__i22__net1 vss 89.7878e-21
c3297 n607__vdd vss 51.0765e-18
c3298 n5__i29__net5 vss 81.8256e-18
c3299 n357__vdd vss 81.9633e-18
c3300 n672__vdd vss 111.53e-18
c3301 n11__i28__i72__x vss 109.462e-18
c3302 n6__i40__i48__x vss 70.9937e-18
c3303 n5__i28__i72__net3 vss 35.1916e-18
c3304 n9__i33__i22__net1 vss 76.3395e-18
c3305 n284__vdd vss 29.5691e-18
c3306 n6__i29__net5 vss 53.0898e-18
c3307 n10__i28__i72__x vss 67.6103e-18
c3308 n6__i33__i22__x vss 75.2674e-18
c3309 n6__i29__i139__x vss 83.6501e-18
c3310 n6__i28__i50__net2 vss 105.593e-18
c3311 n3__i28__i72__net3 vss 50.3859e-18
c3312 n7__net32 vss 52.4798e-18
c3313 n8__out9 vss 48.0308e-18
c3314 n16__net5 vss 126.152e-21
c3315 n7__i33__i22__x vss 109.88e-18
c3316 n114__vdd vss 17.0797e-18
c3317 n7__i29__i139__x vss 98.7029e-18
c3318 n7__i28__i72__net2 vss 42.2559e-21
c3319 n8__net32 vss 70.504e-18
c3320 n6__out9 vss 69.8725e-18
c3321 n673__vdd vss 193.706e-18
c3322 n221__vdd vss 58.8208e-18
c3323 n546__vdd vss 117.837e-18
c3324 n603__vdd vss 60.8934e-18
c3325 n8__i28__i50__net2 vss 163.631e-18
c3326 n358__vdd vss 78.3774e-18
c3327 n3__i28__i72__net2 vss 136.827e-21
c3328 n13__net7 vss 86.5622e-18
c3329 n15__i28__net2 vss 158.378e-18
c3330 n11__i29__net25 vss 302.394e-21
c3331 n540__vdd vss 69.5433e-18
c3332 n193__rst vss 1.68052e-21
c3333 n7__i28__i50__net2 vss 92.8707e-18
c3334 n15__net7 vss 69.0491e-18
c3335 n17__i28__net2 vss 65.2544e-18
c3336 n13__i29__net25 vss 102.624e-18
c3337 n9__i28__i50__net2 vss 161.795e-18
c3338 n4__i40__i49__x vss 71.7775e-18
c3339 n222__vdd vss 53.9061e-18
c3340 n11__i33__i19__net1 vss 89.7878e-21
c3341 n541__vdd vss 62.3484e-18
c3342 n594__vdd vss 51.0765e-18
c3343 n15__i28__net7 vss 162.938e-18
c3344 n5__i29__net11 vss 81.8256e-18
c3345 n359__vdd vss 82.0387e-18
c3346 n5__i28__i50__net2 vss 94.2823e-18
c3347 n6__i40__i49__x vss 70.935e-18
c3348 n9__i33__i19__net1 vss 76.3395e-18
c3349 n285__vdd vss 29.5691e-18
c3350 n17__i28__net7 vss 70.9198e-18
c3351 n6__i29__net11 vss 53.0898e-18
c3352 n6__i33__i19__x vss 75.2674e-18
c3353 n15__i28__net26 vss 66.0596e-18
c3354 n13__i28__net2 vss 80.98e-18
c3355 n6__i29__i138__x vss 84.2253e-18
c3356 n8__net31 vss 52.4798e-18
c3357 n20__i28__net7 vss 72.1569e-18
c3358 n8__out8 vss 48.0308e-18
c3359 n2__net6 vss 126.152e-21
c3360 n7__i33__i19__x vss 109.88e-18
c3361 n16__i28__net26 vss 101.9e-18
c3362 n11__i28__net2 vss 118.213e-18
c3363 n7__i29__i138__x vss 98.7029e-18
c3364 n533__vdd vss 62.2454e-18
c3365 n9__net31 vss 70.504e-18
c3366 n23__i28__net7 vss 129.474e-18
c3367 n6__out8 vss 69.1526e-18
c3368 n223__vdd vss 58.8208e-18
c3369 n534__vdd vss 58.6667e-18
c3370 n588__vdd vss 60.6706e-18
c3371 n360__vdd vss 78.3013e-18
c3372 n13__net8 vss 86.5622e-18
c3373 n14__i28__net17 vss 104.674e-18
c3374 n597__vdd vss 102.791e-18
c3375 n11__i29__net23 vss 177.233e-21
c3376 n526__vdd vss 107.61e-18
c3377 n177__rst vss 1.68052e-21
c3378 n10__i28__net4 vss 99.4693e-18
c3379 n15__net8 vss 69.0491e-18
c3380 n13__i28__net17 vss 61.0766e-18
c3381 n13__i29__net23 vss 103.683e-18
c3382 n12__i28__net4 vss 56.7943e-18
c3383 n4__i40__i50__x vss 71.5218e-18
c3384 n224__vdd vss 53.9061e-18
c3385 n11__i33__i21__net1 vss 89.7878e-21
c3386 n592__vdd vss 61.1514e-18
c3387 n14__i28__i71__net4 vss 61.8589e-18
c3388 n576__vdd vss 51.2988e-18
c3389 n5__i29__net31 vss 81.8256e-18
c3390 n361__vdd vss 81.9633e-18
c3391 n6__i40__i50__x vss 70.9632e-18
c3392 n9__i33__i21__net1 vss 76.3395e-18
c3393 n6__i28__i71__net5 vss 37.8791e-18
c3394 n286__vdd vss 29.5691e-18
c3395 n6__i29__net31 vss 53.0898e-18
c3396 n6__i33__i21__x vss 75.2674e-18
c3397 n32__i28__net12 vss 71.2408e-18
c3398 n6__i29__i137__x vss 84.5823e-18
c3399 n3__i28__i71__net5 vss 46.4965e-18
c3400 n54__i28__net10 vss 112.058e-18
c3401 n7__net30 vss 52.4798e-18
c3402 n8__out7 vss 48.0308e-18
c3403 n2__net7 vss 37.5547e-18
c3404 n7__i33__i21__x vss 109.88e-18
c3405 n33__i28__net12 vss 112.295e-18
c3406 n586__vdd vss 107.295e-18
c3407 n7__i29__i137__x vss 98.9471e-18
c3408 n8__i28__i71__net4 vss 65.2097e-18
c3409 n52__i28__net10 vss 207.407e-18
c3410 n8__net30 vss 70.6506e-18
c3411 n6__out7 vss 69.9381e-18
c3412 n225__vdd vss 58.8208e-18
c3413 n581__vdd vss 104.585e-18
c3414 n520__vdd vss 116.815e-18
c3415 n568__vdd vss 60.6706e-18
c3416 n362__vdd vss 78.3895e-18
c3417 n3__i28__i71__net4 vss 60.1375e-18
c3418 n13__net9 vss 86.5622e-18
c3419 n574__vdd vss 106.234e-18
c3420 n11__i29__net14 vss 177.233e-21
c3421 n514__vdd vss 107.964e-18
c3422 n108__i28__net14 vss 188.372e-18
c3423 n161__rst vss 1.68052e-21
c3424 n15__net9 vss 69.0491e-18
c3425 n13__i29__net14 vss 104.281e-18
c3426 n113__i28__net14 vss 105.215e-18
c3427 n4__i40__i51__x vss 71.9604e-18
c3428 n226__vdd vss 53.9061e-18
c3429 n11__i28__i71__net2 vss 215.755e-21
c3430 n11__i33__i20__net1 vss 89.7878e-21
c3431 n566__vdd vss 180.701e-18
c3432 n556__vdd vss 51.0765e-18
c3433 n5__i29__net15 vss 81.8256e-18
c3434 n363__vdd vss 81.9633e-18
c3435 n11__i28__i71__x vss 109.377e-18
c3436 n6__i40__i51__x vss 70.9937e-18
c3437 n5__i28__i71__net3 vss 35.1458e-18
c3438 n9__i33__i20__net1 vss 76.3395e-18
c3439 n287__vdd vss 29.5691e-18
c3440 n6__i29__net15 vss 53.0898e-18
c3441 n10__i28__i71__x vss 67.7077e-18
c3442 n114__i28__net14 vss 106.372e-18
c3443 n6__i33__i20__x vss 75.2674e-18
c3444 n6__i29__i136__x vss 84.5118e-18
c3445 n3__i28__i71__net3 vss 50.4017e-18
c3446 n7__net43 vss 52.4798e-18
c3447 n8__out6 vss 48.0308e-18
c3448 n2__net8 vss 126.152e-21
c3449 n115__i28__net14 vss 187.695e-18
c3450 n7__i33__i20__x vss 109.88e-18
c3451 n7__i29__i136__x vss 98.9203e-18
c3452 n7__i28__i71__net2 vss 42.2559e-21
c3453 n560__vdd vss 180.565e-18
c3454 n8__net43 vss 70.504e-18
c3455 n6__out6 vss 69.8725e-18
c3456 n508__vdd vss 117.844e-18
c3457 n227__vdd vss 58.8208e-18
c3458 n117__i28__net14 vss 187.653e-18
c3459 n550__vdd vss 61.0763e-18
c3460 n3__i28__i71__net2 vss 136.825e-21
c3461 n364__vdd vss 78.3774e-18
c3462 n554__vdd vss 180.802e-18
c3463 n13__net10 vss 86.5622e-18
c3464 n11__i29__net21 vss 177.233e-21
c3465 n502__vdd vss 69.5705e-18
c3466 n119__i28__net14 vss 186.58e-18
c3467 n145__rst vss 1.68052e-21
c3468 n116__i28__net14 vss 107.809e-18
c3469 n15__net10 vss 69.0491e-18
c3470 n13__i29__net21 vss 104.242e-18
c3471 n118__i28__net14 vss 106.985e-18
c3472 n4__i40__i52__x vss 71.7365e-18
c3473 n548__vdd vss 105.133e-18
c3474 n228__vdd vss 53.9061e-18
c3475 n11__i33__i30__net1 vss 89.7878e-21
c3476 n503__vdd vss 62.2242e-18
c3477 n538__vdd vss 51.2988e-18
c3478 n5__i29__net22 vss 81.8256e-18
c3479 n365__vdd vss 81.9814e-18
c3480 n6__i40__i52__x vss 70.935e-18
c3481 n9__i33__i30__net1 vss 76.3395e-18
c3482 n288__vdd vss 29.5691e-18
c3483 n6__i29__net22 vss 53.0898e-18
c3484 n6__i33__i30__x vss 75.2674e-18
c3485 n15__i28__net23 vss 66.0624e-18
c3486 n6__i29__i135__x vss 84.442e-18
c3487 n246__clk100m vss 105.303e-18
c3488 n7__net42 vss 52.4798e-18
c3489 n8__out5 vss 48.0308e-18
c3490 n543__vdd vss 108.6e-18
c3491 n2__net9 vss 126.152e-21
c3492 n7__i33__i30__x vss 109.88e-18
c3493 n16__i28__net23 vss 100.846e-18
c3494 n7__i29__i135__x vss 98.9164e-18
c3495 n237__clk100m vss 188.44e-18
c3496 n495__vdd vss 62.2227e-18
c3497 n8__net42 vss 70.504e-18
c3498 n6__out5 vss 69.1503e-18
c3499 n536__vdd vss 180.701e-18
c3500 n229__vdd vss 58.8208e-18
c3501 n496__vdd vss 59.2721e-18
c3502 n530__vdd vss 61.1155e-18
c3503 n248__clk100m vss 187.725e-18
c3504 n366__vdd vss 77.8762e-18
c3505 n13__net11 vss 86.5622e-18
c3506 n14__i28__net15 vss 104.59e-18
c3507 n11__i29__net29 vss 177.233e-21
c3508 n528__vdd vss 180.534e-18
c3509 n488__vdd vss 108.172e-18
c3510 n129__rst vss 1.68052e-21
c3511 n247__clk100m vss 107.607e-18
c3512 n15__net11 vss 69.0491e-18
c3513 n13__i28__net15 vss 61.0357e-18
c3514 n13__i29__net29 vss 103.911e-18
c3515 n4__i40__i53__x vss 71.5218e-18
c3516 n250__clk100m vss 187.601e-18
c3517 n230__vdd vss 53.9061e-18
c3518 n11__i33__i23__net1 vss 89.7878e-21
c3519 n14__i28__i70__net4 vss 61.6514e-18
c3520 n518__vdd vss 51.0765e-18
c3521 n522__vdd vss 180.543e-18
c3522 n5__i29__net30 vss 81.8256e-18
c3523 n367__vdd vss 81.9633e-18
c3524 n6__i40__i53__x vss 70.9632e-18
c3525 n249__clk100m vss 103.335e-18
c3526 n9__i33__i23__net1 vss 76.3395e-18
c3527 n6__i28__i70__net5 vss 37.8791e-18
c3528 n289__vdd vss 29.5691e-18
c3529 n6__i29__net30 vss 53.0898e-18
c3530 n6__i33__i23__x vss 75.2674e-18
c3531 n32__i28__net3 vss 71.2399e-18
c3532 n251__clk100m vss 107.589e-18
c3533 n6__i29__i134__x vss 84.1516e-18
c3534 n3__i28__i70__net5 vss 46.4194e-18
c3535 n7__net41 vss 52.4798e-18
c3536 n8__out4 vss 48.0308e-18
c3537 n2__net10 vss 126.152e-21
c3538 n7__i33__i23__x vss 109.88e-18
c3539 n33__i28__net3 vss 112.086e-18
c3540 n252__clk100m vss 187.705e-18
c3541 n7__i29__i134__x vss 98.9133e-18
c3542 n8__i28__i70__net4 vss 65.1916e-18
c3543 n8__net41 vss 70.504e-18
c3544 n6__out4 vss 69.9163e-18
c3545 n516__vdd vss 180.555e-18
c3546 n231__vdd vss 58.8208e-18
c3547 n482__vdd vss 116.825e-18
c3548 n512__vdd vss 60.9003e-18
c3549 n254__clk100m vss 187.743e-18
c3550 n368__vdd vss 78.3895e-18
c3551 n3__i28__i70__net4 vss 60.2454e-18
c3552 n13__net12 vss 86.5622e-18
c3553 n510__vdd vss 180.543e-18
c3554 n11__i29__net16 vss 177.233e-21
c3555 n475__vdd vss 107.95e-18
c3556 n113__rst vss 1.68052e-21
c3557 n253__clk100m vss 106.413e-18
c3558 n15__net12 vss 69.0491e-18
c3559 n13__i29__net16 vss 103.966e-18
c3560 n256__clk100m vss 187.591e-18
c3561 n4__i40__i54__x vss 71.7722e-18
c3562 n11__i28__i70__net2 vss 215.755e-21
c3563 n232__vdd vss 53.9061e-18
c3564 n11__i33__i25__net1 vss 89.7878e-21
c3565 n505__vdd vss 180.543e-18
c3566 n500__vdd vss 51.0765e-18
c3567 n5__i29__net17 vss 81.8256e-18
c3568 n369__vdd vss 81.9633e-18
c3569 n11__i28__i70__x vss 109.714e-18
c3570 n255__clk100m vss 106.363e-18
c3571 n6__i40__i54__x vss 70.9937e-18
c3572 n5__i28__i70__net3 vss 35.1458e-18
c3573 n9__i33__i25__net1 vss 76.3395e-18
c3574 n290__vdd vss 29.5691e-18
c3575 n6__i29__net17 vss 53.0898e-18
c3576 n10__i28__i70__x vss 67.6247e-18
c3577 n6__i33__i25__x vss 75.2674e-18
c3578 n257__clk100m vss 107.555e-18
c3579 n6__i29__i133__x vss 84.1531e-18
c3580 n3__i28__i70__net3 vss 50.3889e-18
c3581 n7__net40 vss 52.4798e-18
c3582 n8__out3 vss 48.0308e-18
c3583 n2__net11 vss 126.152e-21
c3584 n7__i33__i25__x vss 109.88e-18
c3585 n258__clk100m vss 187.735e-18
c3586 n7__i29__i133__x vss 98.9155e-18
c3587 n7__i28__i70__net2 vss 42.2559e-21
c3588 n8__net40 vss 70.504e-18
c3589 n498__vdd vss 180.85e-18
c3590 n6__out3 vss 69.8725e-18
c3591 n467__vdd vss 119.056e-18
c3592 n233__vdd vss 58.8208e-18
c3593 n260__clk100m vss 186.611e-18
c3594 n492__vdd vss 60.9003e-18
c3595 n3__i28__i70__net2 vss 136.825e-21
c3596 n370__vdd vss 78.3774e-18
c3597 n13__net13 vss 86.5622e-18
c3598 n490__vdd vss 107.254e-18
c3599 n459__vdd vss 70.5453e-18
c3600 n11__i29__net9 vss 177.233e-21
c3601 n97__rst vss 1.68052e-21
c3602 n484__vdd vss 109.126e-18
c3603 n259__clk100m vss 107.309e-18
c3604 n15__net13 vss 69.0491e-18
c3605 n13__i29__net9 vss 103.248e-18
c3606 n4__i40__i55__x vss 71.5354e-18
c3607 n234__vdd vss 53.9061e-18
c3608 n11__i33__i24__net1 vss 89.7878e-21
c3609 n98__clk100m_b vss 186.604e-18
c3610 n460__vdd vss 62.1397e-18
c3611 n479__vdd vss 51.0765e-18
c3612 n5__i29__net10 vss 81.8256e-18
c3613 n371__vdd vss 81.9814e-18
c3614 n6__i40__i55__x vss 70.935e-18
c3615 n9__i33__i24__net1 vss 76.3395e-18
c3616 n107__clk100m_b vss 105.994e-18
c3617 n291__vdd vss 29.5691e-18
c3618 n6__i29__net10 vss 53.0898e-18
c3619 n6__i33__i24__x vss 75.4786e-18
c3620 n15__i28__net20 vss 66.022e-18
c3621 n6__i29__i132__x vss 84.6763e-18
c3622 n108__clk100m_b vss 103.757e-18
c3623 n7__net39 vss 52.4798e-18
c3624 n8__out2 vss 48.0308e-18
c3625 n2__net12 vss 126.152e-21
c3626 n7__i33__i24__x vss 109.88e-18
c3627 n16__i28__net20 vss 102.026e-18
c3628 n477__vdd vss 180.021e-18
c3629 n7__i29__i132__x vss 98.9348e-18
c3630 n450__vdd vss 63.5996e-18
c3631 n109__clk100m_b vss 186.655e-18
c3632 n8__net39 vss 70.504e-18
c3633 n6__out2 vss 69.1503e-18
c3634 n235__vdd vss 58.8208e-18
c3635 n469__vdd vss 179.864e-18
c3636 n451__vdd vss 60.8609e-18
c3637 n471__vdd vss 61.1551e-18
c3638 n372__vdd vss 78.4171e-18
c3639 n111__clk100m_b vss 186.954e-18
c3640 n15__i28__net1 vss 105.414e-18
c3641 n25__net14 vss 86.4995e-18
c3642 n11__i29__net19 vss 177.233e-21
c3643 n462__vdd vss 179.864e-18
c3644 n441__vdd vss 108.092e-18
c3645 n81__rst vss 1.68052e-21
c3646 n110__clk100m_b vss 105.533e-18
c3647 n14__i28__net1 vss 61.0357e-18
c3648 n27__net14 vss 69.1398e-18
c3649 n13__i29__net19 vss 104.462e-18
c3650 n4__i40__i56__x vss 71.5218e-18
c3651 n236__vdd vss 53.1287e-18
c3652 n113__clk100m_b vss 186.902e-18
c3653 n11__i33__i29__net1 vss 89.7878e-21
c3654 n14__i28__i69__net4 vss 61.6514e-18
c3655 n455__vdd vss 51.0765e-18
c3656 n5__i29__net20 vss 81.8256e-18
c3657 n373__vdd vss 81.9633e-18
c3658 n453__vdd vss 180.164e-18
c3659 n6__i40__i56__x vss 70.9632e-18
c3660 n112__clk100m_b vss 105.552e-18
c3661 n9__i33__i29__net1 vss 76.3395e-18
c3662 n6__i28__i69__net5 vss 37.8791e-18
c3663 n292__vdd vss 29.5691e-18
c3664 n6__i29__net20 vss 53.0898e-18
c3665 n32__i28__net9 vss 71.2761e-18
c3666 n6__i33__i29__x vss 75.6171e-18
c3667 n6__i29__i131__x vss 84.7176e-18
c3668 n114__clk100m_b vss 104.491e-18
c3669 n3__i28__i69__net5 vss 46.4212e-18
c3670 n7__net38 vss 52.4798e-18
c3671 n8__out1 vss 48.0308e-18
c3672 n33__i28__net9 vss 112.478e-18
c3673 n2__net13 vss 126.152e-21
c3674 n7__i33__i29__x vss 108.96e-18
c3675 n7__i29__i131__x vss 98.8806e-18
c3676 n115__clk100m_b vss 188.059e-18
c3677 n8__i28__i69__net4 vss 65.3307e-18
c3678 n8__net38 vss 70.504e-18
c3679 n6__out1 vss 69.9163e-18
c3680 n443__vdd vss 179.864e-18
c3681 n237__vdd vss 58.8208e-18
c3682 n432__vdd vss 117.07e-18
c3683 n445__vdd vss 61.1748e-18
c3684 n374__vdd vss 78.3895e-18
c3685 n117__clk100m_b vss 186.959e-18
c3686 n3__i28__i69__net4 vss 60.4092e-18
c3687 n13__net15 vss 86.4995e-18
c3688 n11__i29__net26 vss 177.233e-21
c3689 n434__vdd vss 179.926e-18
c3690 n424__vdd vss 107.973e-18
c3691 n65__rst vss 1.68052e-21
c3692 n116__clk100m_b vss 103.694e-18
c3693 n15__net15 vss 69.2685e-18
c3694 n13__i29__net26 vss 103.869e-18
c3695 n4__i40__i57__x vss 71.7722e-18
c3696 n119__clk100m_b vss 186.414e-18
c3697 n12__i28__i69__net2 vss 215.755e-21
c3698 n238__vdd vss 53.1242e-18
c3699 n11__i33__i26__net1 vss 89.7878e-21
c3700 n428__vdd vss 51.4103e-18
c3701 n5__i29__net27 vss 82.2062e-18
c3702 n426__vdd vss 182.117e-18
c3703 n375__vdd vss 82.8737e-18
c3704 n11__i28__i69__x vss 108.272e-18
c3705 n6__i40__i57__x vss 71.0068e-18
c3706 n118__clk100m_b vss 102.335e-18
c3707 n6__i28__i69__net3 vss 35.1524e-18
c3708 n9__i33__i26__net1 vss 76.3345e-18
c3709 n293__vdd vss 28.9397e-18
c3710 n6__i29__net27 vss 53.1313e-18
c3711 n10__i28__i69__x vss 67.6074e-18
c3712 n6__i33__i26__x vss 75.9026e-18
c3713 n6__i29__i130__x vss 83.9643e-18
c3714 n120__clk100m_b vss 105.471e-18
c3715 n3__i28__i69__net3 vss 50.6447e-18
c3716 n7__net19 vss 52.3833e-18
c3717 n3__out0 vss 51.0034e-18
c3718 n14__net14 vss 126.152e-21
c3719 n7__i33__i26__x vss 108.977e-18
c3720 n24__vdd vss 16.9432e-18
c3721 n7__i29__i130__x vss 99.2571e-18
c3722 n121__clk100m_b vss 188.62e-18
c3723 n7__i28__i69__net2 vss 42.2559e-21
c3724 n8__net19 vss 70.1561e-18
c3725 n2__out0 vss 87.7495e-18
c3726 n418__vdd vss 110.222e-18
c3727 n416__vdd vss 118.792e-18
c3728 n239__vdd vss 58.8208e-18
c3729 n420__vdd vss 41.5935e-18
c3730 n24__net16 vss 86.4404e-18
c3731 n26__net16 vss 69.0997e-18
c3732 n9__i33__i28__net1 vss 76.3346e-18
c3733 n294__vdd vss 30.8408e-18
c3734 n380__vdd vss 126.006e-18
c3735 n480__vdd vss 91.7934e-18
c3736 n409__vdd vss 68.3867e-18
c3737 n49__rst vss 1.68052e-21
c3738 n240__vdd vss 52.8913e-18
c3739 n11__i33__i28__net1 vss 89.7878e-21
c3740 n376__vdd vss 309.845e-18
c3741 n6__i33__i28__x vss 75.6523e-18
c3742 n21__net29 vss 181.273e-18
c3743 n29__net23 vss 107.367e-18
c3744 n23__net22 vss 104.905e-18
c3745 n6__net18 vss 53.3003e-18
c3746 n2__net15 vss 49.4027e-21
c3747 n407__vdd vss 102.915e-18
c3748 n7__i33__i28__x vss 110.026e-18
c3749 n22__net29 vss 343.809e-18
c3750 n402__vdd vss 62.2247e-18
c3751 n12__vdd vss 10.7356e-21
c3752 n19__net23 vss 193.181e-18
c3753 n377__vdd vss 339.267e-18
c3754 n13__net22 vss 186.563e-18
c3755 n7__net18 vss 70.5598e-18
c3756 n414__vdd vss 184.654e-18
c3757 n241__vdd vss 59.3294e-18
c3758 n24__net29 vss 342.269e-18
c3759 n400__vdd vss 180.723e-18
c3760 n32__net23 vss 185.813e-18
c3761 n378__vdd vss 358.211e-18
c3762 n12__net17 vss 82.3098e-18
c3763 n26__net22 vss 182.604e-18
c3764 n422__vdd vss 201.783e-18
c3765 n26__net29 vss 342.269e-18
c3766 n398__vdd vss 178.108e-18
c3767 n33__rst vss 3.36104e-21
c3768 n34__net23 vss 183.05e-18
c3769 n242__vdd vss 52.0022e-18
c3770 n379__vdd vss 338.659e-18
c3771 n11__i33__i27__net1 vss 90.0418e-21
c3772 n28__net22 vss 181.203e-18
c3773 n430__vdd vss 179.629e-18
c3774 n27__net29 vss 340.18e-18
c3775 n15__net16 vss 49.4027e-21
c3776 n396__vdd vss 178.108e-18
c3777 n7__i33__i27__x vss 107.781e-18
c3778 n36__net23 vss 183.05e-18
c3779 n382__vdd vss 83.1302e-18
c3780 n30__net22 vss 181.22e-18
c3781 n438__vdd vss 179.629e-18
c3782 n23__net29 vss 180.733e-18
c3783 n7__vdd vss 6.96629e-21
c3784 n31__net23 vss 102.355e-18
c3785 n14__net17 vss 78.477e-18
c3786 n25__net22 vss 101.53e-18
c3787 n25__net29 vss 180.733e-18
c3788 n21__net16 vss 76.5171e-21
c3789 n33__net23 vss 100.72e-18
c3790 n9__i33__i27__net1 vss 76.0983e-18
c3791 n27__net22 vss 100.714e-18
c3792 n20__net29 vss 181.701e-18
c3793 n6__i33__i27__x vss 78.0485e-18
c3794 n35__net23 vss 100.714e-18
c3795 n29__net22 vss 101.066e-18
c3796 n243__vdd vss 35.7579e-18
c3797 n394__vdd vss 178.109e-18
c3798 n38__net23 vss 183.05e-18
c3799 n37__net23 vss 100.714e-18
c3800 n31__net22 vss 101.066e-18
c3801 n16__i33__xor1 vss 94.3474e-18
c3802 n39__net23 vss 100.714e-18
c3803 n33__net22 vss 101.066e-18
c3804 n5__i33__i56__net2 vss 55.6554e-18
c3805 n41__net23 vss 100.733e-18
c3806 n7__i33__i56__net1 vss 42.5248e-18
c3807 n35__net22 vss 101.085e-18
c3808 n28__net23 vss 103.31e-18
c3809 n22__net22 vss 101.623e-18
c3810 n32__net22 vss 181.22e-18
c3811 n447__vdd vss 179.629e-18
c3812 n14__i33__xor1 vss 71.8178e-18
c3813 n392__vdd vss 178.109e-18
c3814 n4__i33__d0 vss 72.8471e-18
c3815 n40__net23 vss 183.05e-18
c3816 n34__net22 vss 181.22e-18
c3817 n7__i33__i56__net2 vss 54.2205e-18
c3818 n457__vdd vss 201.768e-18
c3819 n390__vdd vss 178.109e-18
c3820 n42__net23 vss 183.069e-18
c3821 n9__i33__i56__net1 vss 47.4864e-18
c3822 n36__net22 vss 181.239e-18
c3823 n465__vdd vss 180.627e-18
c3824 n245__vdd vss 46.7362e-18
c3825 n388__vdd vss 179.089e-18
c3826 n43__net23 vss 187.555e-18
c3827 n37__net22 vss 183.678e-18
c3828 n3__i33__i56__net2 vss 55.5403e-18
c3829 n7__i33__i57__net2 vss 41.0716e-18
c3830 n249__vdd vss 44.2208e-18
c3831 n473__vdd vss 107.464e-18
c3832 n386__vdd vss 108.599e-18
c3833 n246__vdd vss 44.1791e-18
c3834 n5__i33__i57__net2 vss 56.4229e-18
c3835 n250__vdd vss 89.9958e-18
c3836 n16__i33__i57__net1 vss 42.8723e-18
c3837 n5__i33__i58__net2 vss 37.6077e-18
c3838 n3__i33__i57__net2 vss 55.8223e-18
c3839 n13__i33__xor2 vss 69.9021e-18
c3840 n14__i33__i58__net1 vss 42.1028e-18
c3841 n6__i33__xor1 vss 111.936e-18
c3842 n247__vdd vss 44.0465e-18
c3843 n14__i33__i57__net1 vss 47.2039e-18
c3844 n7__i33__i58__net2 vss 53.1808e-18
c3845 n210__vdd vss 96.7972e-18
c3846 n11__i33__xor2 vss 266.343e-18
c3847 n16__i33__i58__net1 vss 50.1454e-18
c3848 n5__net16 vss 65.4307e-18
c3849 n3__i33__i58__net2 vss 54.4692e-18
c3850 n8__i33__xor1 vss 71.438e-18
c3851 n7__net14 vss 68.3626e-18
c3852 n2__i33__i58__net1 vss 21.3631e-18
c3853 n4__net5 vss 24.6479e-18
c3854 n2__i33__i57__net1 vss 20.3595e-18
c3855 n4__net17 vss 23.7789e-18
c3856 n2__net14 vss 9.5068e-18
c3857 n2__i33__xor1 vss 9.43847e-18
c3858 n2__net16 vss 9.47793e-18
c3859 n5__i33__xor2 vss 24.8997e-18
c3860 n4__i33__i56__net1 vss 21.0367e-18
c3861 n2__rst vss 17.4181e-18
c3862 n2__i33__i27__x vss 27.2202e-18
c3863 n27__clk1pt6g vss 5.39881e-18
c3864 n106__clk1pt6g vss 14.8256e-18
c3865 n4__clk1pt6g vss 17.4651e-18
c3866 n5__clk1pt6g vss 14.8115e-18
c3867 n6__clk1pt6g vss 14.7978e-18
c3868 n7__clk1pt6g vss 14.8115e-18
c3869 n8__clk1pt6g vss 14.8222e-18
c3870 n9__clk1pt6g vss 16.3131e-18
c3871 n10__clk1pt6g vss 16.9261e-18
c3872 n11__clk1pt6g vss 17.1427e-18
c3873 n12__clk1pt6g vss 18.7056e-18
c3874 n13__clk1pt6g vss 18.6527e-18
c3875 n14__clk1pt6g vss 18.7056e-18
c3876 n15__clk1pt6g vss 18.6527e-18
c3877 n16__clk1pt6g vss 18.7056e-18
c3878 n17__clk1pt6g vss 22.4428e-18
c3879 n19__clk1pt6g vss 4.34272e-18
c3880 n22__clk1pt6g vss 11.4776e-18
c3881 n24__clk1pt6g vss 9.6126e-18
c3882 n28__clk1pt6g vss 15.9613e-18
c3883 n32__clk1pt6g vss 6.14894e-18
c3884 n34__clk1pt6g vss 10.5558e-18
c3885 n36__clk1pt6g vss 9.49219e-18
c3886 n40__clk1pt6g vss 15.9705e-18
c3887 n44__clk1pt6g vss 6.14894e-18
c3888 n46__clk1pt6g vss 10.5558e-18
c3889 n48__clk1pt6g vss 9.49219e-18
c3890 n52__clk1pt6g vss 15.9887e-18
c3891 n56__clk1pt6g vss 6.14894e-18
c3892 n58__clk1pt6g vss 10.5558e-18
c3893 n60__clk1pt6g vss 9.49219e-18
c3894 n64__clk1pt6g vss 15.9686e-18
c3895 n68__clk1pt6g vss 6.14894e-18
c3896 n70__clk1pt6g vss 10.5558e-18
c3897 n72__clk1pt6g vss 9.50572e-18
c3898 n76__clk1pt6g vss 15.9622e-18
c3899 n80__clk1pt6g vss 6.14894e-18
c3900 n82__clk1pt6g vss 10.5558e-18
c3901 n84__clk1pt6g vss 9.51281e-18
c3902 n88__clk1pt6g vss 16.014e-18
c3903 n92__clk1pt6g vss 6.15414e-18
c3904 n94__clk1pt6g vss 10.6182e-18
c3905 n96__clk1pt6g vss 10.5475e-18
c3906 n100__clk1pt6g vss 10.6074e-18
c3907 n104__clk1pt6g vss 6.64591e-18
c3908 n9__i33__i58__net1 vss 32.4194e-18
c3909 n134__clk1pt6g vss 5.40333e-18
c3910 n213__clk1pt6g vss 16.3812e-18
c3911 n111__clk1pt6g vss 14.4331e-18
c3912 n112__clk1pt6g vss 12.6151e-18
c3913 n113__clk1pt6g vss 12.4777e-18
c3914 n114__clk1pt6g vss 12.7725e-18
c3915 n115__clk1pt6g vss 12.4695e-18
c3916 n116__clk1pt6g vss 12.6098e-18
c3917 n117__clk1pt6g vss 12.4525e-18
c3918 n118__clk1pt6g vss 12.6098e-18
c3919 n119__clk1pt6g vss 12.4525e-18
c3920 n120__clk1pt6g vss 12.6098e-18
c3921 n121__clk1pt6g vss 12.4525e-18
c3922 n122__clk1pt6g vss 12.6098e-18
c3923 n123__clk1pt6g vss 12.4525e-18
c3924 n124__clk1pt6g vss 15.1386e-18
c3925 n126__clk1pt6g vss 7.40862e-18
c3926 n129__clk1pt6g vss 19.7217e-18
c3927 n131__clk1pt6g vss 9.4949e-18
c3928 n135__clk1pt6g vss 15.9541e-18
c3929 n139__clk1pt6g vss 9.24213e-18
c3930 n141__clk1pt6g vss 17.9951e-18
c3931 n143__clk1pt6g vss 9.49528e-18
c3932 n147__clk1pt6g vss 15.9613e-18
c3933 n151__clk1pt6g vss 9.24213e-18
c3934 n153__clk1pt6g vss 17.9959e-18
c3935 n155__clk1pt6g vss 9.4733e-18
c3936 n159__clk1pt6g vss 15.9768e-18
c3937 n163__clk1pt6g vss 9.24213e-18
c3938 n165__clk1pt6g vss 17.9959e-18
c3939 n167__clk1pt6g vss 9.49528e-18
c3940 n171__clk1pt6g vss 15.9768e-18
c3941 n175__clk1pt6g vss 9.24213e-18
c3942 n177__clk1pt6g vss 17.9959e-18
c3943 n179__clk1pt6g vss 9.50897e-18
c3944 n183__clk1pt6g vss 15.9768e-18
c3945 n187__clk1pt6g vss 9.24213e-18
c3946 n189__clk1pt6g vss 18.3435e-18
c3947 n191__clk1pt6g vss 9.51545e-18
c3948 n195__clk1pt6g vss 16.0921e-18
c3949 n199__clk1pt6g vss 9.60049e-18
c3950 n201__clk1pt6g vss 18.4089e-18
c3951 n203__clk1pt6g vss 10.5344e-18
c3952 n207__clk1pt6g vss 10.5264e-18
c3953 n211__clk1pt6g vss 9.58126e-18
c3954 n233__clk1pt6g vss 3.1076e-18
c3955 n264__clk1pt6g vss 11.0843e-18
c3956 n218__clk1pt6g vss 16.8473e-18
c3957 n219__clk1pt6g vss 15.0432e-18
c3958 n220__clk1pt6g vss 15.0501e-18
c3959 n221__clk1pt6g vss 15.0432e-18
c3960 n222__clk1pt6g vss 15.0573e-18
c3961 n223__clk1pt6g vss 16.8857e-18
c3962 n225__clk1pt6g vss 3.8813e-18
c3963 n228__clk1pt6g vss 15.6651e-18
c3964 n230__clk1pt6g vss 8.11098e-18
c3965 n234__clk1pt6g vss 11.0581e-18
c3966 n238__clk1pt6g vss 8.56958e-18
c3967 n240__clk1pt6g vss 14.3968e-18
c3968 n242__clk1pt6g vss 8.11136e-18
c3969 n246__clk1pt6g vss 11.0682e-18
c3970 n250__clk1pt6g vss 8.57048e-18
c3971 n252__clk1pt6g vss 14.3913e-18
c3972 n254__clk1pt6g vss 8.11355e-18
c3973 n258__clk1pt6g vss 8.12384e-18
c3974 n262__clk1pt6g vss 8.19549e-18
c3975 n7__rst vss 18.3299e-18
c3976 n2__i33__i28__x vss 26.911e-18
c3977 n8__i33__i57__net1 vss 32.3996e-18
c3978 n9__i33__i57__net1 vss 25.2182e-18
c3979 n8__i28__net1 vss 17.9172e-18
c3980 n12__rst vss 18.3299e-18
c3981 n271__clk1pt6g vss 30.4954e-18
c3982 n273__clk1pt6g vss 17.7098e-18
c3983 n3__net22 vss 17.3888e-18
c3984 n2__i29__i130__x vss 28.2317e-18
c3985 n2__i33__i26__x vss 27.2475e-18
c3986 n2__out1 vss 14.1456e-18
c3987 n8__i28__i69__x vss 18.2555e-18
c3988 n17__rst vss 18.3299e-18
c3989 n7__net22 vss 30.2196e-18
c3990 n9__net22 vss 18.517e-18
c3991 n294__clk1pt6g vss 14.9712e-18
c3992 n2__i29__i131__x vss 28.0618e-18
c3993 n2__i33__i29__x vss 27.2306e-18
c3994 n16__i33__xor2 vss 164.282e-18
c3995 n13__i33__i56__net1 vss 48.0976e-18
c3996 n2__out2 vss 14.1456e-18
c3997 n6__i33__i27__net1 vss 36.894e-18
c3998 n8__i33__i27__net1 vss 33.6244e-18
c3999 n14__net16 vss 36.8609e-18
c4000 n18__net16 vss 42.7218e-18
c4001 n14__i28__net9 vss 28.1086e-18
c4002 n15__i28__net9 vss 24.4139e-18
c4003 n8__i28__net9 vss 23.4236e-18
c4004 n11__i28__net9 vss 8.26197e-18
c4005 n27__rst vss 18.3299e-18
c4006 n5__i33__i27__x vss 44.023e-18
c4007 n2__i29__i132__x vss 28.0618e-18
c4008 n2__i33__i24__x vss 27.2306e-18
c4009 n22__rst_b vss 46.5012e-18
c4010 n141__clk100m vss 5.55684e-18
c4011 n38__clk100m vss 5.74926e-18
c4012 n40__clk100m vss 19.9292e-18
c4013 n41__clk100m vss 16.9094e-18
c4014 n42__clk100m vss 16.8367e-18
c4015 n43__clk100m vss 22.8493e-18
c4016 n44__clk100m vss 19.0707e-18
c4017 n45__clk100m vss 18.6347e-18
c4018 n46__clk100m vss 19.8781e-18
c4019 n47__clk100m vss 30.4886e-18
c4020 n48__clk100m vss 18.3056e-18
c4021 n49__clk100m vss 19.5234e-18
c4022 n50__clk100m vss 19.8032e-18
c4023 n51__clk100m vss 18.4774e-18
c4024 n52__clk100m vss 19.7898e-18
c4025 n53__clk100m vss 35.1192e-18
c4026 n55__clk100m vss 16.3563e-18
c4027 n57__clk100m vss 17.5015e-18
c4028 n59__clk100m vss 8.93142e-18
c4029 n63__clk100m vss 15.5002e-18
c4030 n67__clk100m vss 10.2227e-18
c4031 n69__clk100m vss 17.1862e-18
c4032 n71__clk100m vss 8.92767e-18
c4033 n75__clk100m vss 15.4779e-18
c4034 n79__clk100m vss 9.3917e-18
c4035 n81__clk100m vss 14.9598e-18
c4036 n83__clk100m vss 8.92297e-18
c4037 n87__clk100m vss 15.4869e-18
c4038 n91__clk100m vss 11.4143e-18
c4039 n93__clk100m vss 15.197e-18
c4040 n95__clk100m vss 8.82148e-18
c4041 n99__clk100m vss 15.4693e-18
c4042 n103__clk100m vss 11.2621e-18
c4043 n105__clk100m vss 18.4925e-18
c4044 n107__clk100m vss 8.92058e-18
c4045 n111__clk100m vss 15.4682e-18
c4046 n115__clk100m vss 8.70307e-18
c4047 n117__clk100m vss 16.2043e-18
c4048 n119__clk100m vss 8.82611e-18
c4049 n123__clk100m vss 15.4482e-18
c4050 n127__clk100m vss 10.0244e-18
c4051 n129__clk100m vss 16.6945e-18
c4052 n131__clk100m vss 8.9001e-18
c4053 n135__clk100m vss 8.79024e-18
c4054 n139__clk100m vss 12.0431e-18
c4055 n20__net17 vss 297.355e-18
c4056 n2__out3 vss 14.1456e-18
c4057 n8__i28__net15 vss 17.8143e-18
c4058 n6__i33__i28__net1 vss 40.8566e-18
c4059 n8__i33__i28__net1 vss 33.7924e-18
c4060 n14__net22 vss 26.949e-18
c4061 n15__net22 vss 44.2399e-18
c4062 n16__net22 vss 43.2773e-18
c4063 n17__net22 vss 43.4548e-18
c4064 n18__net22 vss 43.6225e-18
c4065 n19__net22 vss 43.6225e-18
c4066 n20__net22 vss 43.6652e-18
c4067 n21__net22 vss 48.977e-18
c4068 n20__net23 vss 26.0053e-18
c4069 n21__net23 vss 44.4919e-18
c4070 n22__net23 vss 43.3161e-18
c4071 n23__net23 vss 43.3161e-18
c4072 n24__net23 vss 43.3161e-18
c4073 n25__net23 vss 43.3161e-18
c4074 n26__net23 vss 43.3595e-18
c4075 n27__net23 vss 39.9551e-18
c4076 n10__vdd vss 24.6481e-18
c4077 n14__vdd vss 17.6922e-18
c4078 n5__net15 vss 42.3488e-18
c4079 n43__rst vss 18.3299e-18
c4080 n2__i28__net20 vss 30.1354e-18
c4081 n4__i28__net20 vss 18.5185e-18
c4082 n21__i28__net9 vss 17.5997e-18
c4083 n5__net18 vss 59.7551e-18
c4084 n5__i33__i28__x vss 44.1271e-18
c4085 n2__i29__i133__x vss 28.0618e-18
c4086 n16__net29 vss 179.037e-18
c4087 n17__net29 vss 42.7159e-18
c4088 n18__net29 vss 42.4632e-18
c4089 n19__net29 vss 44.9224e-18
c4090 n2__i33__i25__x vss 27.2306e-18
c4091 n31__rst_b vss 22.5184e-18
c4092 n30__net16 vss 32.1098e-18
c4093 n2__out4 vss 14.1456e-18
c4094 n8__i28__i70__x vss 18.1717e-18
c4095 n6__i33__i26__net1 vss 41.1246e-18
c4096 n8__i33__i26__net1 vss 31.8546e-18
c4097 n13__net14 vss 37.4286e-18
c4098 n17__net14 vss 42.3488e-18
c4099 n5__i29__i130__x vss 38.1797e-18
c4100 n25__i28__net9 vss 27.2737e-18
c4101 n27__i28__net9 vss 18.3734e-18
c4102 n10__i28__net20 vss 14.9673e-18
c4103 n59__rst vss 18.3299e-18
c4104 n6__net19 vss 63.905e-18
c4105 n5__i33__i26__x vss 44.0374e-18
c4106 n6__i29__net26 vss 37.188e-18
c4107 n7__i29__net26 vss 24.5927e-18
c4108 n5__i40__i57__x vss 41.2395e-18
c4109 n2__i29__i134__x vss 28.0618e-18
c4110 n2__i33__i23__x vss 27.2306e-18
c4111 n41__rst_b vss 22.0885e-18
c4112 n10__i29__net26 vss 79.3046e-18
c4113 n9__i28__i69__x vss 75.1212e-18
c4114 n2__out5 vss 14.1456e-18
c4115 n4__i29__net27 vss 79.7689e-18
c4116 n19__net15 vss 31.2698e-18
c4117 n7__out1 vss 38.0961e-18
c4118 n6__i33__i29__net1 vss 41.1246e-18
c4119 n32__vdd vss 24.8159e-18
c4120 n36__vdd vss 17.0797e-18
c4121 n5__net13 vss 42.3488e-18
c4122 n105__i28__net14 vss 5.69559e-18
c4123 n2__i28__net14 vss 5.15966e-18
c4124 n4__i28__net14 vss 20.8382e-18
c4125 n5__i28__net14 vss 20.6289e-18
c4126 n6__i28__net14 vss 22.2896e-18
c4127 n7__i28__net14 vss 19.1711e-18
c4128 n8__i28__net14 vss 19.8697e-18
c4129 n9__i28__net14 vss 21.9085e-18
c4130 n10__i28__net14 vss 22.6112e-18
c4131 n11__i28__net14 vss 17.4147e-18
c4132 n12__i28__net14 vss 18.6497e-18
c4133 n13__i28__net14 vss 17.0032e-18
c4134 n14__i28__net14 vss 17.985e-18
c4135 n15__i28__net14 vss 20.7322e-18
c4136 n16__i28__net14 vss 21.3401e-18
c4137 n17__i28__net14 vss 19.0922e-18
c4138 n19__i28__net14 vss 18.6528e-18
c4139 n21__i28__net14 vss 19.2664e-18
c4140 n23__i28__net14 vss 10.2786e-18
c4141 n27__i28__net14 vss 16.768e-18
c4142 n31__i28__net14 vss 7.42418e-18
c4143 n33__i28__net14 vss 18.3924e-18
c4144 n35__i28__net14 vss 10.5588e-18
c4145 n39__i28__net14 vss 16.8349e-18
c4146 n43__i28__net14 vss 9.56936e-18
c4147 n45__i28__net14 vss 16.4043e-18
c4148 n47__i28__net14 vss 10.2657e-18
c4149 n51__i28__net14 vss 16.8275e-18
c4150 n55__i28__net14 vss 8.74809e-18
c4151 n57__i28__net14 vss 16.2807e-18
c4152 n59__i28__net14 vss 10.2657e-18
c4153 n63__i28__net14 vss 16.7305e-18
c4154 n67__i28__net14 vss 9.213e-18
c4155 n69__i28__net14 vss 16.4568e-18
c4156 n71__i28__net14 vss 10.2252e-18
c4157 n75__i28__net14 vss 16.874e-18
c4158 n79__i28__net14 vss 9.59661e-18
c4159 n81__i28__net14 vss 16.5275e-18
c4160 n83__i28__net14 vss 10.3208e-18
c4161 n87__i28__net14 vss 16.7901e-18
c4162 n91__i28__net14 vss 9.72897e-18
c4163 n93__i28__net14 vss 14.848e-18
c4164 n95__i28__net14 vss 10.1414e-18
c4165 n99__i28__net14 vss 10.2265e-18
c4166 n103__i28__net14 vss 11.7317e-18
c4167 n5__i29__i131__x vss 37.3778e-18
c4168 n14__i28__net3 vss 26.4698e-18
c4169 n15__i28__net3 vss 24.4334e-18
c4170 n8__i28__net3 vss 23.3642e-18
c4171 n11__i28__net3 vss 8.26197e-18
c4172 n75__rst vss 18.3299e-18
c4173 n6__net38 vss 63.9566e-18
c4174 n5__i33__i29__x vss 44.0489e-18
c4175 n6__i29__net19 vss 36.7589e-18
c4176 n7__i29__net19 vss 24.5654e-18
c4177 n5__i40__i56__x vss 41.4858e-18
c4178 n2__i29__i135__x vss 28.0618e-18
c4179 n2__i33__i30__x vss 27.2306e-18
c4180 n52__rst_b vss 44.4168e-18
c4181 n31__i28__net9 vss 66.828e-18
c4182 n10__i29__net19 vss 79.4554e-18
c4183 n13__i28__net1 vss 29.5833e-18
c4184 n4__i29__net20 vss 82.2295e-18
c4185 n2__out6 vss 14.1456e-18
c4186 n31__net14 vss 31.4792e-18
c4187 n8__i28__net17 vss 17.8394e-18
c4188 n7__out2 vss 37.0646e-18
c4189 n6__i33__i24__net1 vss 41.1246e-18
c4190 n8__i33__i24__net1 vss 32.0637e-18
c4191 n42__vdd vss 24.8159e-18
c4192 n46__vdd vss 17.0797e-18
c4193 n5__net12 vss 42.3488e-18
c4194 n14__i28__net20 vss 11.6186e-18
c4195 n5__i29__i132__x vss 37.4013e-18
c4196 n99__clk100m_b vss 44.8143e-18
c4197 n100__clk100m_b vss 45.1108e-18
c4198 n101__clk100m_b vss 44.8721e-18
c4199 n102__clk100m_b vss 44.1835e-18
c4200 n103__clk100m_b vss 44.6959e-18
c4201 n104__clk100m_b vss 44.1644e-18
c4202 n105__clk100m_b vss 45.96e-18
c4203 n106__clk100m_b vss 71.331e-18
c4204 n91__rst vss 18.3299e-18
c4205 n2__i28__net23 vss 30.077e-18
c4206 n4__i28__net23 vss 18.5185e-18
c4207 n21__i28__net3 vss 17.5997e-18
c4208 n6__net39 vss 63.9566e-18
c4209 n5__i33__i24__x vss 44.1304e-18
c4210 n6__i29__net9 vss 36.7589e-18
c4211 n7__i29__net9 vss 24.5654e-18
c4212 n5__i40__i55__x vss 41.495e-18
c4213 n2__i29__i136__x vss 28.0618e-18
c4214 n2__i33__i20__x vss 27.2306e-18
c4215 n61__rst_b vss 22.0885e-18
c4216 n10__i29__net9 vss 79.4554e-18
c4217 n49__i28__net10 vss 5.66361e-18
c4218 n2__i28__net10 vss 19.2239e-18
c4219 n4__i28__net10 vss 20.4827e-18
c4220 n5__i28__net10 vss 18.8188e-18
c4221 n6__i28__net10 vss 23.1807e-18
c4222 n7__i28__net10 vss 15.7123e-18
c4223 n8__i28__net10 vss 18.2453e-18
c4224 n9__i28__net10 vss 20.2577e-18
c4225 n11__i28__net10 vss 17.8224e-18
c4226 n13__i28__net10 vss 16.7997e-18
c4227 n15__i28__net10 vss 10.1972e-18
c4228 n19__i28__net10 vss 16.7489e-18
c4229 n23__i28__net10 vss 8.084e-18
c4230 n25__i28__net10 vss 17.9712e-18
c4231 n27__i28__net10 vss 10.1879e-18
c4232 n31__i28__net10 vss 16.7285e-18
c4233 n35__i28__net10 vss 7.64208e-18
c4234 n37__i28__net10 vss 18.8679e-18
c4235 n39__i28__net10 vss 10.2637e-18
c4236 n43__i28__net10 vss 10.2241e-18
c4237 n47__i28__net10 vss 12.4111e-18
c4238 n4__i29__net10 vss 82.2295e-18
c4239 n19__net13 vss 31.5839e-18
c4240 n2__out7 vss 14.1456e-18
c4241 n8__i28__i71__x vss 18.1789e-18
c4242 n7__out3 vss 37.9504e-18
c4243 n8__i33__i25__net1 vss 32.0647e-18
c4244 n52__vdd vss 24.8159e-18
c4245 n56__vdd vss 17.0797e-18
c4246 n5__net11 vss 42.3488e-18
c4247 n9__i28__net4 vss 3.44085e-18
c4248 n2__i28__net4 vss 5.48853e-18
c4249 n5__i28__net4 vss 12.2756e-18
c4250 n5__i29__i133__x vss 37.4128e-18
c4251 n28__i28__net3 vss 12.5467e-18
c4252 n10__i28__net23 vss 14.5598e-18
c4253 n107__rst vss 18.3299e-18
c4254 n6__net40 vss 63.9566e-18
c4255 n5__i33__i25__x vss 44.1304e-18
c4256 n6__i29__net16 vss 36.7589e-18
c4257 n7__i29__net16 vss 24.5654e-18
c4258 n5__i40__i54__x vss 41.4508e-18
c4259 n2__i29__i137__x vss 28.0618e-18
c4260 n2__i33__i21__x vss 27.2306e-18
c4261 n71__rst_b vss 22.0885e-18
c4262 n10__i29__net16 vss 79.4554e-18
c4263 n9__i28__i70__x vss 74.5428e-18
c4264 n4__i29__net17 vss 82.2295e-18
c4265 n19__net12 vss 31.5839e-18
c4266 n9__i28__net2 vss 5.80778e-18
c4267 n2__i28__net2 vss 7.43209e-18
c4268 n5__i28__net2 vss 10.9219e-18
c4269 n2__out8 vss 14.1456e-18
c4270 n7__out4 vss 38.035e-18
c4271 n6__i33__i23__net1 vss 41.1246e-18
c4272 n8__i33__i23__net1 vss 32.0637e-18
c4273 n62__vdd vss 24.8159e-18
c4274 n66__vdd vss 17.0797e-18
c4275 n5__net10 vss 42.3488e-18
c4276 n5__i29__i134__x vss 37.3778e-18
c4277 n14__i28__net12 vss 27.7772e-18
c4278 n15__i28__net12 vss 25.1469e-18
c4279 n8__i28__net12 vss 24.9073e-18
c4280 n11__i28__net12 vss 8.2338e-18
c4281 n123__rst vss 18.3299e-18
c4282 n6__net41 vss 63.9566e-18
c4283 n5__i33__i23__x vss 44.1304e-18
c4284 n6__i29__net29 vss 36.7589e-18
c4285 n7__i29__net29 vss 24.5654e-18
c4286 n5__i40__i53__x vss 41.5771e-18
c4287 n2__i29__i138__x vss 28.0618e-18
c4288 n2__i33__i19__x vss 27.2306e-18
c4289 n31__i28__net3 vss 66.5262e-18
c4290 n81__rst_b vss 22.0885e-18
c4291 n10__i29__net29 vss 79.4554e-18
c4292 n12__i28__net15 vss 29.4945e-18
c4293 n2__out9 vss 14.1456e-18
c4294 n4__i29__net30 vss 82.2295e-18
c4295 n19__net11 vss 31.5839e-18
c4296 n8__i28__net19 vss 17.8528e-18
c4297 n7__out5 vss 37.0646e-18
c4298 n6__i33__i30__net1 vss 41.1246e-18
c4299 n8__i33__i30__net1 vss 32.0637e-18
c4300 n238__clk100m vss 40.3685e-18
c4301 n239__clk100m vss 43.854e-18
c4302 n240__clk100m vss 42.7987e-18
c4303 n241__clk100m vss 43.501e-18
c4304 n242__clk100m vss 43.271e-18
c4305 n243__clk100m vss 43.2657e-18
c4306 n244__clk100m vss 43.5689e-18
c4307 n245__clk100m vss 32.3522e-18
c4308 n72__vdd vss 24.8159e-18
c4309 n76__vdd vss 17.0797e-18
c4310 n5__net9 vss 42.3488e-18
c4311 n14__i28__net23 vss 11.4597e-18
c4312 n5__i29__i135__x vss 37.4347e-18
c4313 n3__i28__net7 vss 16.0603e-18
c4314 n139__rst vss 18.3299e-18
c4315 n6__net42 vss 63.9566e-18
c4316 n5__i33__i30__x vss 44.1304e-18
c4317 n2__i28__net26 vss 30.4932e-18
c4318 n4__i28__net26 vss 18.3676e-18
c4319 n21__i28__net12 vss 17.5993e-18
c4320 n6__i29__net21 vss 36.7589e-18
c4321 n7__i29__net21 vss 24.5654e-18
c4322 n5__i40__i52__x vss 41.495e-18
c4323 n2__i29__i139__x vss 28.0618e-18
c4324 n2__i33__i22__x vss 27.2306e-18
c4325 n91__rst_b vss 22.0885e-18
c4326 n10__i29__net21 vss 79.4554e-18
c4327 n4__i29__net22 vss 82.2295e-18
c4328 n19__net10 vss 31.5839e-18
c4329 n2__i28__net8 vss 68.2825e-18
c4330 n3__i28__net8 vss 99.0682e-18
c4331 n5__i28__net8 vss 19.0761e-18
c4332 n7__i28__net8 vss 139.794e-18
c4333 n8__i28__net8 vss 149.104e-18
c4334 n8__i28__i72__x vss 18.1717e-18
c4335 n2__out10 vss 14.1456e-18
c4336 n7__out6 vss 37.9555e-18
c4337 n6__i33__i20__net1 vss 41.1246e-18
c4338 n8__i33__i20__net1 vss 32.0637e-18
c4339 n82__vdd vss 24.8159e-18
c4340 n86__vdd vss 17.0797e-18
c4341 n5__net8 vss 42.3488e-18
c4342 n5__i29__i136__x vss 37.3778e-18
c4343 n25__i28__net12 vss 26.2228e-18
c4344 n27__i28__net12 vss 18.3734e-18
c4345 n10__i28__net26 vss 14.9673e-18
c4346 n46__net22 vss 28.66e-18
c4347 n48__net22 vss 19.1212e-18
c4348 n454__clk1pt6g vss 18.6876e-18
c4349 n451__clk1pt6g vss 8.45842e-18
c4350 n155__rst vss 18.3299e-18
c4351 n6__net43 vss 63.9566e-18
c4352 n5__i33__i20__x vss 44.1304e-18
c4353 n5__i40__i51__x vss 41.4075e-18
c4354 n2__i29__i140__x vss 28.0618e-18
c4355 n109__i28__net14 vss 43.083e-18
c4356 n110__i28__net14 vss 43.5757e-18
c4357 n111__i28__net14 vss 43.9e-18
c4358 n112__i28__net14 vss 49.3447e-18
c4359 n2__i33__i17__x vss 27.2306e-18
c4360 n101__rst_b vss 22.0885e-18
c4361 n9__i28__i71__x vss 74.6565e-18
c4362 n10__i29__net14 vss 79.4554e-18
c4363 n4__i29__net15 vss 82.2295e-18
c4364 n19__net9 vss 30.9008e-18
c4365 n7__i28__i53__x vss 7.28156e-18
c4366 n8__i28__i53__x vss 3.7139e-18
c4367 n4__i28__i53__x vss 14.6517e-18
c4368 n2__out11 vss 14.1456e-18
c4369 n7__out7 vss 38.0689e-18
c4370 n6__i33__i21__net1 vss 41.1246e-18
c4371 n8__i33__i21__net1 vss 32.057e-18
c4372 n53__i28__net10 vss 47.7809e-18
c4373 n184__clk100m_b vss 23.322e-18
c4374 n92__vdd vss 24.8159e-18
c4375 n96__vdd vss 17.0797e-18
c4376 n475__clk1pt6g vss 32.1733e-18
c4377 n477__clk1pt6g vss 18.3036e-18
c4378 n56__net22 vss 20.7812e-18
c4379 n53__net22 vss 9.68098e-18
c4380 n14__i28__net13 vss 27.487e-18
c4381 n15__i28__net13 vss 25.2832e-18
c4382 n8__i28__net13 vss 24.2483e-18
c4383 n11__i28__net13 vss 8.2338e-18
c4384 n5__i29__i137__x vss 37.4347e-18
c4385 n171__rst vss 18.3299e-18
c4386 n6__net30 vss 63.296e-18
c4387 n5__i33__i21__x vss 44.1304e-18
c4388 n6__i29__net23 vss 36.7589e-18
c4389 n7__i29__net23 vss 24.5654e-18
c4390 n5__i40__i50__x vss 41.6128e-18
c4391 n2__i29__i141__x vss 28.0618e-18
c4392 n11__i28__net4 vss 55.571e-18
c4393 n2__i33__i18__x vss 27.2728e-18
c4394 n31__i28__net12 vss 66.3406e-18
c4395 n111__rst_b vss 22.0885e-18
c4396 n10__i29__net23 vss 79.4554e-18
c4397 n12__i28__net17 vss 29.4931e-18
c4398 n13__i28__net7 vss 7.0645e-18
c4399 n14__i28__net7 vss 3.90303e-18
c4400 n10__i28__net7 vss 13.671e-18
c4401 n2__out12 vss 14.1456e-18
c4402 n4__i29__net31 vss 82.2295e-18
c4403 n19__net8 vss 31.5839e-18
c4404 n8__i28__net5 vss 17.8399e-18
c4405 n7__out8 vss 37.0646e-18
c4406 n6__i33__i19__net1 vss 41.1246e-18
c4407 n8__i33__i19__net1 vss 32.0637e-18
c4408 n102__vdd vss 24.8159e-18
c4409 n106__vdd vss 17.0797e-18
c4410 n5__net6 vss 42.3488e-18
c4411 n14__i28__net26 vss 11.4372e-18
c4412 n58__net22 vss 31.6626e-18
c4413 n60__net22 vss 18.9887e-18
c4414 n504__clk1pt6g vss 20.7762e-18
c4415 n501__clk1pt6g vss 8.89995e-18
c4416 n16__i28__net7 vss 52.8597e-18
c4417 n19__i28__net7 vss 40.4928e-18
c4418 n5__i29__i138__x vss 37.3195e-18
c4419 n187__rst vss 18.3299e-18
c4420 n2__i28__net11 vss 29.4259e-18
c4421 n4__i28__net11 vss 18.3287e-18
c4422 n21__i28__net13 vss 17.5993e-18
c4423 n7__net31 vss 63.9566e-18
c4424 n5__i33__i19__x vss 44.1304e-18
c4425 n6__i29__net25 vss 36.7589e-18
c4426 n7__i29__net25 vss 24.5654e-18
c4427 n5__i40__i49__x vss 41.495e-18
c4428 n2__i29__i142__x vss 28.0618e-18
c4429 n2__i33__i16__x vss 27.2728e-18
c4430 n121__rst_b vss 22.0885e-18
c4431 n19__i28__net2 vss 33.4995e-18
c4432 n20__i28__net2 vss 42.4441e-18
c4433 n10__i29__net25 vss 79.4554e-18
c4434 n7__i28__i52__x vss 7.0984e-18
c4435 n8__i28__i52__x vss 3.72573e-18
c4436 n4__i28__i52__x vss 14.519e-18
c4437 n4__i29__net11 vss 82.2295e-18
c4438 n19__net7 vss 31.5839e-18
c4439 n8__i28__i51__x vss 18.1701e-18
c4440 n2__out13 vss 14.1456e-18
c4441 n7__out9 vss 38.0627e-18
c4442 n6__i33__i22__net1 vss 41.1246e-18
c4443 n8__i33__i22__net1 vss 32.0637e-18
c4444 n2__i28__i50__net2 vss 56.8696e-18
c4445 n3__i28__i50__net2 vss 50.1574e-18
c4446 n4__i28__i50__net2 vss 41.0133e-18
c4447 n525__clk1pt6g vss 30.4003e-18
c4448 n527__clk1pt6g vss 18.289e-18
c4449 n68__net22 vss 20.9186e-18
c4450 n65__net22 vss 9.9997e-18
c4451 n15__net5 vss 37.4286e-18
c4452 n19__net5 vss 42.3488e-18
c4453 n5__i29__i139__x vss 37.3002e-18
c4454 n25__i28__net13 vss 30.5067e-18
c4455 n27__i28__net13 vss 18.3705e-18
c4456 n10__i28__net11 vss 14.9773e-18
c4457 n203__rst vss 18.4101e-18
c4458 n6__net32 vss 63.9566e-18
c4459 n5__i33__i22__x vss 44.1304e-18
c4460 n6__i29__net12 vss 36.7589e-18
c4461 n7__i29__net12 vss 24.5654e-18
c4462 n5__i40__i48__x vss 41.4336e-18
c4463 n2__i29__i143__x vss 28.0618e-18
c4464 n2__i33__i0__x vss 28.2854e-18
c4465 n9__i28__i72__x vss 74.3165e-18
c4466 n131__rst_b vss 22.0885e-18
c4467 n10__i29__net12 vss 79.4554e-18
c4468 n7__i28__net6 vss 4.57161e-18
c4469 n8__i28__net6 vss 4.34161e-18
c4470 n4__i28__net6 vss 13.6518e-18
c4471 n4__i29__net5 vss 82.2295e-18
c4472 n19__net6 vss 31.5839e-18
c4473 n2__out14 vss 14.1456e-18
c4474 n7__out10 vss 38.0689e-18
c4475 n6__i33__i17__net1 vss 41.1246e-18
c4476 n18__i28__net8 vss 67.8044e-18
c4477 n17__i28__net6 vss 19.6663e-18
c4478 n122__vdd vss 24.8159e-18
c4479 n126__vdd vss 17.0797e-18
c4480 n5__net4 vss 42.3488e-18
c4481 n5__i29__i140__x vss 37.4347e-18
c4482 n7__net33 vss 63.9566e-18
c4483 n5__i33__i17__x vss 44.1304e-18
c4484 n6__i29__net6 vss 36.7589e-18
c4485 n7__i29__net6 vss 24.5654e-18
c4486 n5__i40__i47__x vss 41.596e-18
c4487 n2__i29__i144__x vss 28.0618e-18
c4488 n9__net21 vss 16.0462e-18
c4489 n5__net21 vss 4.1462e-18
c4490 n31__i28__net13 vss 66.3375e-18
c4491 n136__rst_b vss 22.0885e-18
c4492 n10__i29__net6 vss 79.4554e-18
c4493 n12__i28__net19 vss 29.4956e-18
c4494 n2__out15 vss 14.1519e-18
c4495 n4__i29__net1 vss 82.2295e-18
c4496 n31__net5 vss 31.5839e-18
c4497 n7__out11 vss 37.0646e-18
c4498 n6__i33__i18__net1 vss 41.1814e-18
c4499 n8__i33__i18__net1 vss 32.2506e-18
c4500 n10__i28__i53__x vss 69.13e-18
c4501 n9__net24 vss 12.0012e-18
c4502 n5__net24 vss 4.78564e-18
c4503 n132__vdd vss 24.8159e-18
c4504 n136__vdd vss 17.0797e-18
c4505 n5__net3 vss 42.3488e-18
c4506 n14__i28__net11 vss 11.4373e-18
c4507 n5__i29__i141__x vss 37.4347e-18
c4508 n6__net34 vss 63.9566e-18
c4509 n5__i33__i18__x vss 44.6773e-18
c4510 n6__i29__net34 vss 36.7589e-18
c4511 n7__i29__net34 vss 24.5654e-18
c4512 n5__i40__i46__x vss 41.495e-18
c4513 n2__i29__i161__x vss 28.0032e-18
c4514 n2__ext_tx vss 485.684e-18
c4515 n8__ext_tx vss 407.065e-18
c4516 n143__rst_b vss 22.0885e-18
c4517 n13__i29__net34 vss 79.4554e-18
c4518 n4__i29__net2 vss 82.2295e-18
c4519 n19__net4 vss 108.268e-18
c4520 n7__out12 vss 38.1076e-18
c4521 n7__i33__i16__net1 vss 32.2506e-18
c4522 n2__net25 vss 151.652e-18
c4523 n5__net25 vss 18.2755e-18
c4524 n2__net28 vss 14.2341e-18
c4525 n30__i28__net7 vss 40.3514e-18
c4526 n142__vdd vss 24.8159e-18
c4527 n146__vdd vss 17.0797e-18
c4528 n5__net2 vss 42.3488e-18
c4529 n5__i29__i142__x vss 37.4347e-18
c4530 n5__net35 vss 63.9566e-18
c4531 n5__i33__i16__x vss 44.6773e-18
c4532 n6__i29__net18 vss 36.7589e-18
c4533 n7__i29__net18 vss 24.5654e-18
c4534 n5__i40__i45__x vss 41.4597e-18
c4535 n9__i28__i51__x vss 74.198e-18
c4536 n4__i29__net3 vss 82.2295e-18
c4537 n6__out13 vss 38.0706e-18
c4538 n4__i33__i0__net1 vss 41.1814e-18
c4539 n7__i33__i0__net1 vss 32.2612e-18
c4540 n10__i28__i52__x vss 68.4299e-18
c4541 n150__vdd vss 24.813e-18
c4542 n154__vdd vss 17.0797e-18
c4543 n5__i33__d0 vss 37.3297e-18
c4544 n9__i33__d0 vss 42.3488e-18
c4545 n5__i29__i143__x vss 37.4347e-18
c4546 n5__net36 vss 63.9566e-18
c4547 n5__i33__i0__x vss 44.0769e-18
c4548 n6__i29__net13 vss 36.7589e-18
c4549 n7__i29__net13 vss 24.5654e-18
c4550 n5__i40__i44__x vss 41.5791e-18
c4551 n18__i28__net6 vss 66.6303e-18
c4552 n12__i28__net5 vss 31.0029e-18
c4553 n156__vdd vss 174.363e-18
c4554 n157__vdd vss 62.3457e-18
c4555 n158__vdd vss 49.4421e-18
c4556 n159__vdd vss 127.566e-18
c4557 n160__vdd vss 61.5431e-18
c4558 n161__vdd vss 49.4362e-18
c4559 n162__vdd vss 127.566e-18
c4560 n163__vdd vss 61.508e-18
c4561 n164__vdd vss 49.2266e-18
c4562 n165__vdd vss 127.56e-18
c4563 n166__vdd vss 61.1772e-18
c4564 n167__vdd vss 49.1137e-18
c4565 n168__vdd vss 127.566e-18
c4566 n169__vdd vss 61.2248e-18
c4567 n170__vdd vss 49.3233e-18
c4568 n171__vdd vss 127.566e-18
c4569 n172__vdd vss 61.2248e-18
c4570 n173__vdd vss 49.3233e-18
c4571 n174__vdd vss 127.566e-18
c4572 n175__vdd vss 61.2248e-18
c4573 n176__vdd vss 49.3233e-18
c4574 n177__vdd vss 127.566e-18
c4575 n178__vdd vss 61.2248e-18
c4576 n179__vdd vss 49.3233e-18
c4577 n180__vdd vss 127.566e-18
c4578 n181__vdd vss 61.2248e-18
c4579 n182__vdd vss 49.3233e-18
c4580 n183__vdd vss 127.566e-18
c4581 n184__vdd vss 61.2248e-18
c4582 n185__vdd vss 49.3233e-18
c4583 n186__vdd vss 127.566e-18
c4584 n187__vdd vss 61.2291e-18
c4585 n188__vdd vss 49.3233e-18
c4586 n189__vdd vss 127.566e-18
c4587 n190__vdd vss 61.2248e-18
c4588 n191__vdd vss 49.3238e-18
c4589 n192__vdd vss 127.566e-18
c4590 n193__vdd vss 61.2248e-18
c4591 n194__vdd vss 49.3238e-18
c4592 n195__vdd vss 127.56e-18
c4593 n196__vdd vss 61.2251e-18
c4594 n197__vdd vss 49.267e-18
c4595 n198__vdd vss 127.752e-18
c4596 n199__vdd vss 61.5192e-18
c4597 n200__vdd vss 50.8934e-18
c4598 n201__vdd vss 128.926e-18
c4599 n202__vdd vss 60.4001e-18
c4600 n203__vdd vss 87.4833e-18
c4601 n204__vdd vss 97.1235e-18
c4602 n205__vdd vss 15.4532e-18
c4603 n206__vdd vss 29.0488e-18
c4604 n207__vdd vss 73.7571e-18
c4605 n208__vdd vss 45.9844e-18
c4606 n209__vdd vss 86.8021e-18
c4607 n244__vdd vss 6.85488e-18
c4608 n248__vdd vss 80.3318e-18
c4609 n4__i29__net4 vss 82.2295e-18
c4610 n6__out14 vss 37.0729e-18
c4611 n254__vdd vss 22.5591e-18
c4612 n258__vdd vss 14.778e-18
c4613 n5__i29__i144__x vss 37.41e-18
c4614 n5__net37 vss 63.2208e-18
c4615 n260__vdd vss 6.59881e-18
c4616 n262__vdd vss 116.325e-18
c4617 n264__vdd vss 116.16e-18
c4618 n266__vdd vss 116.16e-18
c4619 n267__vdd vss 116.16e-18
c4620 n268__vdd vss 116.16e-18
c4621 n269__vdd vss 116.16e-18
c4622 n270__vdd vss 116.652e-18
c4623 n271__vdd vss 116.16e-18
c4624 n272__vdd vss 116.16e-18
c4625 n273__vdd vss 116.16e-18
c4626 n274__vdd vss 116.16e-18
c4627 n275__vdd vss 116.16e-18
c4628 n276__vdd vss 116.16e-18
c4629 n277__vdd vss 116.226e-18
c4630 n278__vdd vss 113.873e-18
c4631 n6__i29__net7 vss 36.1067e-18
c4632 n7__i29__net7 vss 22.965e-18
c4633 n5__i40__i43__x vss 41.495e-18
c4634 n10__net24 vss 54.2207e-18
c4635 n4__i29__net8 vss 81.9051e-18
c4636 n6__out15 vss 38.1793e-18
c4637 n5__i29__i161__x vss 37.691e-18
c4638 n5__i40__i42__x vss 45.848e-18
c4639 n2__net1 vss 135.818e-18
c4640 n3__net1 vss 96.4559e-18
c4641 n6__net28 vss 329.876e-18
c4642 n296__vdd vss 117.62e-18
c4643 n297__vdd vss 12.328e-18
c4644 n302__vdd vss 39.716e-18
c4645 n303__vdd vss 72.9706e-18
c4646 n304__vdd vss 143.049e-18
c4647 n305__vdd vss 120.863e-18
c4648 n306__vdd vss 146.661e-18
c4649 n307__vdd vss 119.737e-18
c4650 n308__vdd vss 147.1e-18
c4651 n309__vdd vss 123.011e-18
c4652 n310__vdd vss 147.347e-18
c4653 n311__vdd vss 123.41e-18
c4654 n312__vdd vss 147.611e-18
c4655 n313__vdd vss 119.248e-18
c4656 n314__vdd vss 147.234e-18
c4657 n315__vdd vss 123.429e-18
c4658 n316__vdd vss 147.153e-18
c4659 n317__vdd vss 123.681e-18
c4660 n318__vdd vss 147.772e-18
c4661 n319__vdd vss 119.59e-18
c4662 n320__vdd vss 147.487e-18
c4663 n321__vdd vss 123.473e-18
c4664 n322__vdd vss 147.105e-18
c4665 n323__vdd vss 123.56e-18
c4666 n324__vdd vss 147.94e-18
c4667 n325__vdd vss 119.877e-18
c4668 n326__vdd vss 147.635e-18
c4669 n327__vdd vss 123.459e-18
c4670 n328__vdd vss 147.224e-18
c4671 n329__vdd vss 122.783e-18
c4672 n330__vdd vss 148.088e-18
c4673 n331__vdd vss 119.84e-18
c4674 n332__vdd vss 147.739e-18
c4675 n333__vdd vss 123.447e-18
c4676 n334__vdd vss 144.865e-18
c4677 n335__vdd vss 79.8135e-18
c4678 n336__vdd vss 61.9222e-18
c4679 n337__vdd vss 58.0615e-18
c4680 n338__vdd vss 54.7057e-18
c4681 n339__vdd vss 64.2336e-18
c4682 n340__vdd vss 79.3085e-18
c4683 n341__vdd vss 98.2945e-18
c4684 n383__vdd vss 71.9855e-18
c4685 n385__vdd vss 69.2738e-18
c4686 n387__vdd vss 85.467e-18
c4687 n389__vdd vss 85.4504e-18
c4688 n391__vdd vss 85.4504e-18
c4689 n393__vdd vss 85.4504e-18
c4690 n395__vdd vss 85.4504e-18
c4691 n397__vdd vss 85.4504e-18
c4692 n399__vdd vss 143.78e-18
c4693 n401__vdd vss 44.6973e-18
c4694 n403__vdd vss 117.511e-18
c4695 n404__vdd vss 45.9202e-18
c4696 n405__vdd vss 44.8086e-18
c4697 n406__vdd vss 16.0398e-18
c4698 n408__vdd vss 23.4462e-18
c4699 n410__vdd vss 17.7215e-18
c4700 n412__vdd vss 52.4592e-18
c4701 n413__vdd vss 25.7192e-18
c4702 n415__vdd vss 78.8456e-18
c4703 n417__vdd vss 34.2243e-18
c4704 n419__vdd vss 57.791e-18
c4705 n421__vdd vss 26.1272e-18
c4706 n423__vdd vss 70.3687e-18
c4707 n425__vdd vss 48.3518e-18
c4708 n427__vdd vss 114.482e-18
c4709 n429__vdd vss 26.4524e-18
c4710 n431__vdd vss 98.9212e-18
c4711 n433__vdd vss 48.2878e-18
c4712 n435__vdd vss 67.9472e-18
c4713 n437__vdd vss 26.4524e-18
c4714 n439__vdd vss 103.008e-18
c4715 n440__vdd vss 29.466e-18
c4716 n442__vdd vss 49.3377e-18
c4717 n444__vdd vss 57.5857e-18
c4718 n446__vdd vss 26.4524e-18
c4719 n448__vdd vss 34.7988e-18
c4720 n449__vdd vss 31.0038e-18
c4721 n452__vdd vss 47.0066e-18
c4722 n454__vdd vss 114.307e-18
c4723 n456__vdd vss 26.4537e-18
c4724 n458__vdd vss 39.1725e-18
c4725 n461__vdd vss 48.6267e-18
c4726 n463__vdd vss 67.8302e-18
c4727 n464__vdd vss 26.4618e-18
c4728 n466__vdd vss 113.266e-18
c4729 n468__vdd vss 48.6604e-18
c4730 n470__vdd vss 57.5796e-18
c4731 n472__vdd vss 19.2498e-18
c4732 n474__vdd vss 69.2889e-18
c4733 n476__vdd vss 49.1121e-18
c4734 n478__vdd vss 114.307e-18
c4735 n481__vdd vss 124.728e-18
c4736 n483__vdd vss 34.9369e-18
c4737 n485__vdd vss 67.8302e-18
c4738 n486__vdd vss 101.657e-18
c4739 n487__vdd vss 28.4208e-18
c4740 n489__vdd vss 27.7534e-18
c4741 n491__vdd vss 57.5719e-18
c4742 n493__vdd vss 34.8376e-18
c4743 n494__vdd vss 30.7506e-18
c4744 n497__vdd vss 47.7458e-18
c4745 n499__vdd vss 114.307e-18
c4746 n501__vdd vss 40.1792e-18
c4747 n504__vdd vss 47.2096e-18
c4748 n506__vdd vss 67.8302e-18
c4749 n507__vdd vss 108.985e-18
c4750 n509__vdd vss 45.4224e-18
c4751 n511__vdd vss 57.5792e-18
c4752 n513__vdd vss 68.9465e-18
c4753 n515__vdd vss 48.7223e-18
c4754 n517__vdd vss 114.306e-18
c4755 n519__vdd vss 124.235e-18
c4756 n521__vdd vss 46.2909e-18
c4757 n523__vdd vss 67.8302e-18
c4758 n524__vdd vss 95.1266e-18
c4759 n525__vdd vss 28.857e-18
c4760 n527__vdd vss 46.5666e-18
c4761 n529__vdd vss 57.5796e-18
c4762 n531__vdd vss 37.1941e-18
c4763 n532__vdd vss 30.6512e-18
c4764 n535__vdd vss 49.2018e-18
c4765 n537__vdd vss 114.326e-18
c4766 n539__vdd vss 37.7309e-18
c4767 n542__vdd vss 30.0071e-18
c4768 n544__vdd vss 67.8302e-18
c4769 n545__vdd vss 102.38e-18
c4770 n547__vdd vss 33.5014e-18
c4771 n549__vdd vss 57.5796e-18
c4772 n551__vdd vss 84.1291e-18
c4773 n553__vdd vss 43.6628e-18
c4774 n555__vdd vss 114.306e-18
c4775 n557__vdd vss 125.413e-18
c4776 n559__vdd vss 47.6764e-18
c4777 n561__vdd vss 67.8302e-18
c4778 n562__vdd vss 100.83e-18
c4779 n563__vdd vss 28.5232e-18
c4780 n565__vdd vss 48.5385e-18
c4781 n567__vdd vss 57.5796e-18
c4782 n569__vdd vss 31.9972e-18
c4783 n570__vdd vss 30.6523e-18
c4784 n573__vdd vss 30.6218e-18
c4785 n575__vdd vss 114.326e-18
c4786 n577__vdd vss 38.6138e-18
c4787 n580__vdd vss 31.9228e-18
c4788 n582__vdd vss 67.8302e-18
c4789 n583__vdd vss 108.322e-18
c4790 n585__vdd vss 49.16e-18
c4791 n587__vdd vss 57.5351e-18
c4792 n589__vdd vss 65.0542e-18
c4793 n591__vdd vss 31.3224e-18
c4794 n593__vdd vss 114.069e-18
c4795 n595__vdd vss 122.412e-18
c4796 n598__vdd vss 67.9763e-18
c4797 n599__vdd vss 41.4632e-18
c4798 n600__vdd vss 30.0412e-18
c4799 n602__vdd vss 57.4687e-18
c4800 n606__vdd vss 113.913e-18
c4801 n608__vdd vss 68.2054e-18
c4802 n609__vdd vss 57.5796e-18
c4803 n611__vdd vss 114.326e-18
c4804 n613__vdd vss 67.8302e-18
c4805 n614__vdd vss 57.5796e-18
c4806 n616__vdd vss 114.326e-18
c4807 n618__vdd vss 67.8302e-18
c4808 n619__vdd vss 57.5796e-18
c4809 n621__vdd vss 114.326e-18
c4810 n623__vdd vss 67.8302e-18
c4811 n624__vdd vss 57.5792e-18
c4812 n626__vdd vss 114.326e-18
c4813 n628__vdd vss 67.8302e-18
c4814 n629__vdd vss 57.5796e-18
c4815 n631__vdd vss 114.326e-18
c4816 n633__vdd vss 66.5025e-18
c4817 n634__vdd vss 50.0556e-18
c4818 n636__vdd vss 101.734e-18
c4819 n9__net25 vss 106.977e-18
c4820 n640__vdd vss 113.248e-18
c4821 n643__vdd vss 96.38e-18
c4822 n645__vdd vss 26.8331e-18
c4823 n647__vdd vss 39.5999e-18
c4824 n649__vdd vss 23.9979e-18
c4825 n651__vdd vss 26.5248e-18
c4826 n653__vdd vss 61.6693e-18
c4827 n655__vdd vss 82.0043e-18
c4828 n657__vdd vss 58.551e-18
c4829 n659__vdd vss 83.2986e-18
c4830 n661__vdd vss 61.1835e-18
c4831 n663__vdd vss 81.3266e-18
c4832 n665__vdd vss 61.0941e-18
c4833 n667__vdd vss 118.066e-18
c4834 n669__vdd vss 60.8347e-18
c4835 n671__vdd vss 45.964e-18
c4836 n151__rst_b vss 22.0885e-18
c4837 n13__i29__net18 vss 79.4554e-18
c4838 n19__net3 vss 31.5839e-18
c4839 n154__rst_b vss 18.0268e-18
c4840 n13__i29__net13 vss 79.4554e-18
c4841 n13__i29__net7 vss 71.4356e-18
c4842 n174__net23 vss 167.466e-18
c4843 n175__net23 vss 161.347e-18
c4844 n176__net23 vss 160.919e-18
c4845 n177__net23 vss 159.385e-18
c4846 n178__net23 vss 174.75e-18
c4847 n179__net23 vss 261.43e-18
c4848 n180__net23 vss 154.9e-18
c4849 n181__net23 vss 141.468e-18
c4850 n182__net23 vss 144.282e-18
c4851 n183__net23 vss 141.62e-18
c4852 n184__net23 vss 142.424e-18
c4853 n185__net23 vss 143.256e-18
c4854 n186__net23 vss 143.436e-18
c4855 n187__net23 vss 145.25e-18
c4856 n26__net2 vss 104.824e-18
c4857 n370__clk100m vss 471.024e-18
c4858 n371__clk100m vss 223.359e-18
c4859 n372__clk100m vss 591.531e-18
c4860 n375__clk100m vss 111.773e-18
c4861 n377__clk100m vss 127.242e-18
c4862 n378__clk100m vss 128.81e-18
c4863 n379__clk100m vss 131.203e-18
c4864 n380__clk100m vss 132.572e-18
c4865 n381__clk100m vss 132.572e-18
c4866 n382__clk100m vss 132.572e-18
c4867 n383__clk100m vss 132.808e-18
c4868 n384__clk100m vss 129.892e-18
c4869 n385__clk100m vss 132.572e-18
c4870 n386__clk100m vss 132.572e-18
c4871 n387__clk100m vss 131.892e-18
c4872 n388__clk100m vss 128.818e-18
c4873 n389__clk100m vss 135.975e-18
c4874 n632__clk1pt6g vss 105.931e-18
c4875 n633__clk1pt6g vss 64.4079e-18
c4876 n634__clk1pt6g vss 64.4084e-18
c4877 n635__clk1pt6g vss 64.4e-18
c4878 n636__clk1pt6g vss 64.4051e-18
c4879 n637__clk1pt6g vss 64.4064e-18
c4880 n638__clk1pt6g vss 64.4e-18
c4881 n639__clk1pt6g vss 64.4071e-18
c4882 n640__clk1pt6g vss 64.4049e-18
c4883 n641__clk1pt6g vss 64.4e-18
c4884 n642__clk1pt6g vss 64.408e-18
c4885 n643__clk1pt6g vss 64.4041e-18
c4886 n644__clk1pt6g vss 64.378e-18
c4887 n645__clk1pt6g vss 64.4089e-18
c4888 n646__clk1pt6g vss 64.4044e-18
c4889 n647__clk1pt6g vss 65.3817e-18
c4890 n79__net22 vss 512.509e-18
c4891 n649__clk1pt6g vss 439.201e-18
c4892 n650__clk1pt6g vss 50.2219e-18
c4893 n651__clk1pt6g vss 19.7915e-18
c4894 n652__clk1pt6g vss 181.565e-18
rg1 n36__net5 n13__net5 10.1253
rg2 n160__rst_b n159__rst_b 618.5e-3
rg3 n159__rst_b n158__rst_b 618.5e-3
rg4 n158__rst_b n139__rst_b 618.5e-3
rg5 n139__rst_b n123__rst_b 618.5e-3
rg6 n123__rst_b n113__rst_b 618.5e-3
rg7 n113__rst_b n103__rst_b 618.5e-3
rg8 n103__rst_b n93__rst_b 618.5e-3
rg9 n93__rst_b n83__rst_b 618.5e-3
rg10 n83__rst_b n73__rst_b 618.5e-3
rg11 n73__rst_b n63__rst_b 618.5e-3
rg12 n63__rst_b n53__rst_b 618.5e-3
rg13 n53__rst_b n43__rst_b 618.5e-3
rg14 n43__rst_b n33__rst_b 618.5e-3
rg15 n33__rst_b n23__rst_b 618.5e-3
rg16 n23__rst_b n13__rst_b 623.3e-3
rg17 n13__rst_b rst_b 911.7e-3
rh1 n12__net5 n13__net5 500e-3
rh2 n9__net16 n10__net16 1.209
rh3 n18__i33__xor1 n13__i33__xor1 709e-3
rh4 n13__i33__xor1 n10__i33__xor1 1.0811
rh5 n13__rst_b n14__rst_b 1.088
rh6 n6__vdd n3__vdd 1.1538
rh7 n23__rst_b n24__rst_b 1.088
rh8 n34__net16 n23__net16 1.7164
rh9 n52__net23 n45__net23 1.1288
rh10 n33__rst_b n34__rst_b 1.088
rh11 n10__net15 n12__net15 1.2164
rh12 n43__rst_b n44__rst_b 1.088
rh13 n20__net14 n24__net14 1.1986
rh14 n24__net14 n12__net14 4.1081
rh15 n12__net14 n9__net14 709e-3
rh16 n53__rst_b n54__rst_b 1.088
rh17 n10__net13 n12__net13 1.1986
rh18 n63__rst_b n64__rst_b 1.088
rh19 n10__net12 n12__net12 1.1986
rh20 n73__rst_b n74__rst_b 1.088
rh21 n10__net11 n12__net11 1.1986
rh22 n83__rst_b n84__rst_b 1.088
rh23 n10__net10 n12__net10 1.1986
rh24 n93__rst_b n94__rst_b 1.088
rh25 n10__net9 n12__net9 1.1986
rh26 n103__rst_b n104__rst_b 1.088
rh27 n10__net8 n12__net8 1.1986
rh28 n113__rst_b n114__rst_b 1.088
rh29 n10__net7 n12__net7 1.1986
rh30 n123__rst_b n124__rst_b 1.088
rh31 n10__net6 n12__net6 1.1986
rh32 n139__rst_b n138__rst_b 588e-3
rh33 n24__net5 n36__net5 1.0324
rh34 n36__net5 n35__net5 108.2e-3
rh35 n158__rst_b n145__rst_b 588e-3
rh36 n10__net4 n12__net4 1.1986
rh37 n78__net22 n79__net22 2.0816
rh38 n79__net22 n44__net22 5.487
rh39 n44__net22 n39__net22 1.8079
rh40 n79__net22 n71__net22 878.6e-3
rh41 n159__rst_b n156__rst_b 588e-3
rh42 n24__net3 n25__net3 1.1986
rh43 n629__clk1pt6g n649__clk1pt6g 1.3351
rh44 n649__clk1pt6g n334__clk1pt6g 7.7008
rh45 n334__clk1pt6g n650__clk1pt6g 2.2847
rh46 n650__clk1pt6g n651__clk1pt6g 119.5e-3
rh47 n651__clk1pt6g clk1pt6g 25.76e-3
rh48 n649__clk1pt6g n566__clk1pt6g 139.3e-3
rh49 n650__clk1pt6g n287__clk1pt6g 464.9e-3
rh50 n287__clk1pt6g n304__clk1pt6g 2.3859
rh51 n304__clk1pt6g n648__clk1pt6g 1.7002
rh52 n651__clk1pt6g n286__clk1pt6g 363.5e-3
rh53 n286__clk1pt6g n652__clk1pt6g 2.1932
rh55 n652__clk1pt6g n630__clk1pt6g 312.5e-3
rh56 n251__clk100m_b n250__clk100m_b 618.5e-3
rh57 n250__clk100m_b n238__clk100m_b 618.5e-3
rh58 n238__clk100m_b n228__clk100m_b 618.5e-3
rh59 n228__clk100m_b n214__clk100m_b 618.5e-3
rh60 n214__clk100m_b n200__clk100m_b 618.5e-3
rh61 n200__clk100m_b n186__clk100m_b 618.5e-3
rh62 n186__clk100m_b n170__clk100m_b 618.5e-3
rh63 n170__clk100m_b n156__clk100m_b 618.5e-3
rh64 n156__clk100m_b n142__clk100m_b 618.5e-3
rh65 n142__clk100m_b n127__clk100m_b 618.5e-3
rh66 n127__clk100m_b n90__clk100m_b 618.5e-3
rh67 n90__clk100m_b n76__clk100m_b 618.5e-3
rh68 n76__clk100m_b n61__clk100m_b 618.5e-3
rh69 n61__clk100m_b n44__clk100m_b 618.5e-3
rh70 n44__clk100m_b n30__clk100m_b 1.1185
rh71 n160__rst_b n157__rst_b 588e-3
rh72 n25__net2 n26__net2 1.764
rh73 n155__net29 n154__net29 618.5e-3
rh74 n154__net29 n153__net29 618.5e-3
rh75 n153__net29 n152__net29 618.5e-3
rh76 n152__net29 n132__net29 618.5e-3
rh77 n132__net29 n124__net29 618.5e-3
rh78 n124__net29 n115__net29 618.5e-3
rh79 n115__net29 n106__net29 618.5e-3
rh80 n106__net29 n97__net29 618.5e-3
rh81 n97__net29 n88__net29 618.5e-3
rh82 n88__net29 n79__net29 618.5e-3
rh83 n79__net29 n70__net29 618.5e-3
rh84 n70__net29 n61__net29 618.5e-3
rh85 n61__net29 n52__net29 618.5e-3
rh86 n52__net29 n43__net29 618.5e-3
rh87 n43__net29 n34__net29 618.5e-3
ri1 n9__net14 n6__net14 500e-3
ri2 n10__net5 n12__net5 1
ri3 n11__i33__i58__net1 n7__i33__i58__net1 1.0855
ri4 n10__i33__xor1 n9__i33__xor1 500e-3
ri5 n8__net16 n9__net16 500e-3
ri6 n11__i33__i57__net1 n10__i33__i57__net1 1.0855
ri7 n8__i33__i58__net2 n4__i33__i58__net2 394.2e-3
ri8 n11__net14 n12__net14 500e-3
ri9 n8__i33__i57__net2 n4__i33__i57__net2 394.2e-3
ri10 n12__i33__xor1 n13__i33__xor1 500e-3
ri11 n286__clk1pt6g n284__clk1pt6g 500e-3
ri12 n285__clk1pt6g n287__clk1pt6g 500e-3
ri13 n8__i33__i56__net2 n4__i33__i56__net2 894.5e-3
ri14 n2__vdd n3__vdd 500e-3
ri15 n18__i33__xor1 n17__i33__xor1 500e-3
ri16 n16__i33__i56__net1 n12__i33__i56__net1 1.5852
ri17 n303__clk1pt6g n304__clk1pt6g 500e-3
ri20 n12__i33__i27__net1 n5__i33__i27__net1 755.4e-3
ri21 n31__rst n24__rst 898.7e-3
ri22 n20__rst_b n14__rst_b 4.832e-3
ri23 n5__vdd n6__vdd 500e-3
ri24 n22__net16 n23__net16 500e-3
ri25 n44__clk100m_b n45__clk100m_b 1
ri26 n38__net22 n39__net22 500e-3
ri27 n22__net17 n18__net17 1.3985
ri28 n44__net23 n45__net23 500e-3
ri29 n12__i33__i28__net1 n4__i33__i28__net1 755.4e-3
ri30 n47__rst n40__rst 898.7e-3
ri31 n32__rst_b n24__rst_b 4.832e-3
ri32 n9__net18 n8__net18 1.2773
ri33 n33__net16 n34__net16 155.7e-3
ri34 n34__net16 n13__net16 1.4399
ri35 n13__net16 n10__net16 616.5e-3
ri37 n9__net15 n10__net15 500e-3
ri38 n51__net23 n52__net23 1
ri39 n61__clk100m_b n62__clk100m_b 1
ri40 n35__net16 n30__net16 1.3985
ri41 n33__net29 n34__net29 1
ri42 n333__clk1pt6g n334__clk1pt6g 500e-3
ri43 n12__i33__i26__net1 n5__i33__i26__net1 769.4e-3
ri44 n9__net19 n10__net19 370.2e-3
ri45 n10__net19 n4__net19 398.5e-3
ri46 n63__rst n56__rst 898.7e-3
ri47 n42__rst_b n34__rst_b 4.832e-3
ri48 n11__net15 n12__net15 1.1557
ri49 n19__net14 n20__net14 1
ri50 n76__clk100m_b n75__clk100m_b 500e-3
ri51 n22__net15 n19__net15 1.3985
ri52 n42__net29 n43__net29 1
ri53 n43__net22 n44__net22 500e-3
ri54 n12__i33__i29__net1 n5__i33__i29__net1 769.4e-3
ri55 n9__net38 n10__net38 370.2e-3
ri56 n10__net38 n4__net38 398.5e-3
ri57 n79__rst n72__rst 898.7e-3
ri58 n50__rst_b n44__rst_b 4.832e-3
ri59 n23__net14 n24__net14 1.1557
ri60 n9__net13 n10__net13 500e-3
ri61 n16__i28__net1 n10__i28__net1 1.3607
ri62 n90__clk100m_b n89__clk100m_b 500e-3
ri63 n34__net14 n31__net14 1.3985
ri64 n51__net29 n52__net29 1
ri65 n12__i33__i24__net1 n5__i33__i24__net1 769.4e-3
ri66 n9__net39 n10__net39 370.2e-3
ri67 n10__net39 n4__net39 398.5e-3
ri68 n95__rst n88__rst 898.7e-3
ri69 n62__rst_b n54__rst_b 4.832e-3
ri70 n11__net13 n12__net13 1.1557
ri71 n9__net12 n10__net12 500e-3
ri72 n127__clk100m_b n126__clk100m_b 500e-3
ri73 n22__net13 n19__net13 1.3985
ri74 n60__net29 n61__net29 1
ri75 n12__i33__i25__net1 n5__i33__i25__net1 769.4e-3
ri76 n9__net40 n10__net40 370.2e-3
ri77 n10__net40 n4__net40 398.5e-3
ri78 n111__rst n104__rst 898.7e-3
ri79 n72__rst_b n64__rst_b 4.832e-3
ri80 n11__net12 n12__net12 1.1557
ri81 n9__net11 n10__net11 500e-3
ri82 n38__i28__net9 n35__i28__net9 2.006
ri83 n141__clk100m_b n142__clk100m_b 500e-3
ri84 n22__net12 n19__net12 1.3985
ri85 n69__net29 n70__net29 1
ri86 n12__i33__i23__net1 n5__i33__i23__net1 769.4e-3
ri87 n9__net41 n10__net41 370.2e-3
ri88 n10__net41 n4__net41 398.5e-3
ri89 n127__rst n120__rst 898.7e-3
ri90 n82__rst_b n74__rst_b 4.832e-3
ri91 n11__net11 n12__net11 1.1557
ri92 n15__i28__net15 n10__i28__net15 1.365
ri93 n9__net10 n10__net10 500e-3
ri94 n156__clk100m_b n155__clk100m_b 500e-3
ri95 n22__net11 n19__net11 1.3985
ri96 n78__net29 n79__net29 1
ri97 n12__i33__i30__net1 n5__i33__i30__net1 769.4e-3
ri98 n9__net42 n10__net42 370.2e-3
ri99 n10__net42 n4__net42 398.5e-3
ri100 n143__rst n136__rst 898.7e-3
ri101 n92__rst_b n84__rst_b 4.832e-3
ri102 n11__net10 n12__net10 1.1557
ri103 n9__net9 n10__net9 500e-3
ri104 n170__clk100m_b n169__clk100m_b 500e-3
ri105 n22__net10 n19__net10 1.3985
ri106 n87__net29 n88__net29 1
ri107 n12__i33__i20__net1 n5__i33__i20__net1 769.4e-3
ri108 n9__net43 n10__net43 370.2e-3
ri109 n10__net43 n4__net43 398.5e-3
ri110 n159__rst n152__rst 898.7e-3
ri111 n102__rst_b n94__rst_b 4.832e-3
ri112 n11__net9 n12__net9 1.1557
ri113 n9__net8 n10__net8 500e-3
ri114 n38__i28__net3 n35__i28__net3 1.9472
ri115 n185__clk100m_b n186__clk100m_b 500e-3
ri116 n22__net9 n19__net9 1.3985
ri117 n96__net29 n97__net29 1
ri118 n12__i33__i21__net1 n5__i33__i21__net1 769.4e-3
ri119 n9__net30 n10__net30 370.2e-3
ri120 n10__net30 n4__net30 398.5e-3
ri121 n175__rst n168__rst 898.7e-3
ri122 n112__rst_b n104__rst_b 4.832e-3
ri123 n11__net8 n12__net8 1.1557
ri124 n15__i28__net17 n10__i28__net17 1.365
ri125 n9__net7 n10__net7 500e-3
ri126 n200__clk100m_b n199__clk100m_b 500e-3
ri127 n22__net8 n19__net8 1.3985
ri128 n105__net29 n106__net29 1
ri129 n12__i33__i19__net1 n5__i33__i19__net1 769.4e-3
ri130 n6__net31 n10__net31 370.2e-3
ri131 n10__net31 n4__net31 398.5e-3
ri132 n191__rst n184__rst 898.7e-3
ri133 n122__rst_b n114__rst_b 4.832e-3
ri134 n11__net7 n12__net7 1.1557
ri135 n9__net6 n10__net6 500e-3
ri136 n214__clk100m_b n213__clk100m_b 500e-3
ri137 n22__net7 n19__net7 1.3985
ri138 n114__net29 n115__net29 1
ri139 n12__i33__i22__net1 n5__i33__i22__net1 769.4e-3
ri140 n9__net32 n10__net32 370.2e-3
ri141 n10__net32 n4__net32 398.5e-3
ri142 n207__rst n200__rst 898.7e-3
ri143 n132__rst_b n124__rst_b 4.832e-3
ri144 n11__net6 n12__net6 1.1557
ri145 n23__net5 n24__net5 500e-3
ri146 n70__net22 n71__net22 500e-3
ri147 n38__i28__net12 n35__i28__net12 1.9472
ri148 n227__clk100m_b n228__clk100m_b 500e-3
ri149 n22__net6 n19__net6 1.3985
ri150 n123__net29 n124__net29 1
ri151 n12__i33__i17__net1 n5__i33__i17__net1 769.4e-3
ri152 n5__net33 n10__net33 370.2e-3
ri153 n10__net33 n4__net33 398.5e-3
ri154 n218__rst n217__rst 898.7e-3
ri155 n137__rst_b n138__rst_b 504.8e-3
ri156 n34__net5 n35__net5 655.7e-3
ri157 n15__i28__net19 n10__i28__net19 1.365
ri158 n9__net4 n10__net4 500e-3
ri159 n565__clk1pt6g n566__clk1pt6g 500e-3
ri160 n238__clk100m_b n237__clk100m_b 500e-3
ri161 n40__net5 n31__net5 898.5e-3
ri162 n131__net29 n132__net29 1
ri163 n12__i33__i18__net1 n5__i33__i18__net1 769.4e-3
ri164 n9__net34 n13__net34 370.2e-3
ri165 n13__net34 n4__net34 398.5e-3
ri166 n229__rst n228__rst 898.7e-3
ri167 n144__rst_b n145__rst_b 504.8e-3
ri168 n11__net4 n12__net4 1.1557
ri169 n9__net3 n24__net3 500e-3
ri170 n28__i28__net7 n26__i28__net7 1.4934
ri171 n75__net22 n78__net22 500e-3
ri172 n250__clk100m_b n248__clk100m_b 500e-3
ri173 n25__net4 n19__net4 898.5e-3
ri174 n146__net29 n152__net29 500e-3
ri175 n12__i33__i16__net1 n8__i33__i16__net1 769.4e-3
ri176 n12__net35 n13__net35 370.2e-3
ri177 n13__net35 n11__net35 398.5e-3
ri178 n254__rst n253__rst 398.7e-3
ri179 n152__rst_b n156__rst_b 504.8e-3
ri180 n22__net3 n25__net3 655.7e-3
ri181 n18__net2 n25__net2 500e-3
ri182 n619__clk1pt6g n629__clk1pt6g 500e-3
ri183 n39__i28__net13 n35__i28__net13 1.4496
ri184 n251__clk100m_b n249__clk100m_b 500e-3
ri185 n23__net3 n19__net3 898.5e-3
ri186 n147__net29 n153__net29 1
ri187 n12__i33__i0__net1 n11__i33__i0__net1 769.4e-3
ri188 n12__net36 n13__net36 370.2e-3
ri189 n13__net36 n11__net36 398.5e-3
ri190 n256__rst n255__rst 398.7e-3
ri191 n155__rst_b n157__rst_b 504.8e-3
ri192 n15__i28__net5 n10__i28__net5 1.365
ri193 n23__net2 n26__net2 115.3e-3
ri196 n21__net2 n26__net2 500e-3
ri197 n23__i28__net6 n24__i28__net6 896.3e-3
ri198 n24__net2 n19__net2 898.5e-3
ri199 n149__net29 n154__net29 500e-3
ri200 n12__net37 n13__net37 370.2e-3
ri201 n13__net37 n11__net37 398.5e-3
ri202 n369__clk100m n367__clk100m 618.5e-3
ri203 n367__clk100m n365__clk100m 618.5e-3
ri204 n365__clk100m n349__clk100m 618.5e-3
ri205 n349__clk100m n339__clk100m 618.5e-3
ri206 n339__clk100m n326__clk100m 618.5e-3
ri207 n326__clk100m n311__clk100m 618.5e-3
ri208 n311__clk100m n295__clk100m 618.5e-3
ri209 n295__clk100m n280__clk100m 618.5e-3
ri210 n280__clk100m n265__clk100m 618.5e-3
ri211 n265__clk100m n226__clk100m 618.5e-3
ri212 n226__clk100m n211__clk100m 618.5e-3
ri213 n211__clk100m n194__clk100m 618.5e-3
ri214 n194__clk100m n179__clk100m 618.5e-3
ri215 n179__clk100m n164__clk100m 618.5e-3
ri216 n164__clk100m n370__clk100m 557.3e-3
ri217 n370__clk100m n371__clk100m 1.9031
ri218 n371__clk100m n372__clk100m 154.7e-3
ri221 n370__clk100m n202__clk100m 3.3162
ri222 n371__clk100m n375__clk100m 496.4e-3
ri223 n375__clk100m n156__clk100m 60.13e-3
ri224 n372__clk100m n33__clk100m 60.13e-3
ri226 n375__clk100m n377__clk100m 645.1e-3
ri227 n377__clk100m n171__clk100m 60.13e-3
ri228 n377__clk100m n378__clk100m 645.1e-3
ri229 n378__clk100m n184__clk100m 60.13e-3
ri230 n378__clk100m n379__clk100m 645.1e-3
ri231 n379__clk100m n201__clk100m 60.13e-3
ri232 n379__clk100m n380__clk100m 645.1e-3
ri233 n380__clk100m n218__clk100m 60.13e-3
ri234 n380__clk100m n381__clk100m 645.1e-3
ri235 n381__clk100m n233__clk100m 60.13e-3
ri236 n381__clk100m n382__clk100m 645.1e-3
ri237 n382__clk100m n272__clk100m 60.13e-3
ri238 n382__clk100m n383__clk100m 645.1e-3
ri239 n383__clk100m n287__clk100m 60.13e-3
ri240 n383__clk100m n384__clk100m 645.1e-3
ri241 n384__clk100m n303__clk100m 560.1e-3
ri242 n384__clk100m n385__clk100m 645.1e-3
ri243 n385__clk100m n318__clk100m 60.13e-3
ri244 n385__clk100m n386__clk100m 645.1e-3
ri245 n386__clk100m n333__clk100m 60.13e-3
ri246 n386__clk100m n387__clk100m 645.1e-3
ri247 n387__clk100m n346__clk100m 60.13e-3
ri248 n387__clk100m n388__clk100m 645.1e-3
ri249 n388__clk100m n353__clk100m 60.13e-3
ri250 n388__clk100m n389__clk100m 645.1e-3
ri251 n389__clk100m n366__clk100m 60.13e-3
ri252 n389__clk100m n368__clk100m 708.5e-3
ri253 n151__net29 n155__net29 500e-3
ri254 n627__clk1pt6g n624__clk1pt6g 618.5e-3
ri255 n624__clk1pt6g n621__clk1pt6g 618.5e-3
ri256 n621__clk1pt6g n617__clk1pt6g 618.5e-3
ri257 n617__clk1pt6g n577__clk1pt6g 618.5e-3
ri258 n577__clk1pt6g n554__clk1pt6g 618.5e-3
ri259 n554__clk1pt6g n531__clk1pt6g 618.5e-3
ri260 n531__clk1pt6g n505__clk1pt6g 618.5e-3
ri261 n505__clk1pt6g n481__clk1pt6g 618.5e-3
ri262 n481__clk1pt6g n455__clk1pt6g 618.5e-3
ri263 n455__clk1pt6g n434__clk1pt6g 618.5e-3
ri264 n434__clk1pt6g n412__clk1pt6g 618.5e-3
ri265 n412__clk1pt6g n393__clk1pt6g 618.5e-3
ri266 n393__clk1pt6g n374__clk1pt6g 618.5e-3
ri267 n374__clk1pt6g n355__clk1pt6g 618.5e-3
ri268 n355__clk1pt6g n335__clk1pt6g 618.5e-3
ri269 n335__clk1pt6g n630__clk1pt6g 1.0914
ri270 n17__net20 n14__net20 898.5e-3
ri271 n16__net20 n15__net20 398.5e-3
ri273 n632__clk1pt6g n626__clk1pt6g 162.4e-3
ri274 n626__clk1pt6g n633__clk1pt6g 462e-3
ri275 n633__clk1pt6g n623__clk1pt6g 162.4e-3
ri276 n623__clk1pt6g n634__clk1pt6g 462e-3
ri277 n634__clk1pt6g n620__clk1pt6g 162.4e-3
ri278 n620__clk1pt6g n635__clk1pt6g 462e-3
ri279 n635__clk1pt6g n616__clk1pt6g 162.4e-3
ri280 n616__clk1pt6g n636__clk1pt6g 462e-3
ri281 n636__clk1pt6g n573__clk1pt6g 162.4e-3
ri282 n573__clk1pt6g n637__clk1pt6g 462e-3
ri283 n637__clk1pt6g n549__clk1pt6g 162.4e-3
ri284 n549__clk1pt6g n638__clk1pt6g 462e-3
ri285 n638__clk1pt6g n523__clk1pt6g 162.4e-3
ri286 n523__clk1pt6g n639__clk1pt6g 462e-3
ri287 n639__clk1pt6g n499__clk1pt6g 162.4e-3
ri288 n499__clk1pt6g n640__clk1pt6g 462e-3
ri289 n640__clk1pt6g n473__clk1pt6g 162.4e-3
ri290 n473__clk1pt6g n641__clk1pt6g 462e-3
ri291 n641__clk1pt6g n449__clk1pt6g 162.4e-3
ri292 n449__clk1pt6g n642__clk1pt6g 462e-3
ri293 n642__clk1pt6g n430__clk1pt6g 162.4e-3
ri294 n430__clk1pt6g n643__clk1pt6g 462e-3
ri295 n643__clk1pt6g n411__clk1pt6g 162.4e-3
ri296 n411__clk1pt6g n644__clk1pt6g 462e-3
ri297 n644__clk1pt6g n392__clk1pt6g 162.4e-3
ri298 n392__clk1pt6g n645__clk1pt6g 462e-3
ri299 n645__clk1pt6g n373__clk1pt6g 162.4e-3
ri300 n373__clk1pt6g n646__clk1pt6g 462e-3
ri301 n646__clk1pt6g n354__clk1pt6g 162.4e-3
ri302 n354__clk1pt6g n647__clk1pt6g 462e-3
ri303 n647__clk1pt6g n331__clk1pt6g 162.4e-3
ri304 n331__clk1pt6g n648__clk1pt6g 500e-3
ri305 n632__clk1pt6g n628__clk1pt6g 676.5e-3
ri306 n633__clk1pt6g n625__clk1pt6g 676.5e-3
ri307 n634__clk1pt6g n622__clk1pt6g 676.5e-3
ri308 n635__clk1pt6g n618__clk1pt6g 676.5e-3
ri309 n636__clk1pt6g n584__clk1pt6g 676.5e-3
ri310 n637__clk1pt6g n556__clk1pt6g 676.5e-3
ri311 n638__clk1pt6g n541__clk1pt6g 676.5e-3
ri312 n639__clk1pt6g n515__clk1pt6g 676.5e-3
ri313 n640__clk1pt6g n486__clk1pt6g 676.5e-3
ri314 n641__clk1pt6g n460__clk1pt6g 676.5e-3
ri315 n642__clk1pt6g n436__clk1pt6g 676.5e-3
ri316 n643__clk1pt6g n417__clk1pt6g 676.5e-3
ri317 n644__clk1pt6g n398__clk1pt6g 676.5e-3
ri318 n645__clk1pt6g n379__clk1pt6g 676.5e-3
ri319 n646__clk1pt6g n360__clk1pt6g 676.5e-3
ri320 n647__clk1pt6g n342__clk1pt6g 676.5e-3
rj1 n5__net14 n6__net14 1
rj2 n7__i33__i58__net1 n8__i33__i58__net1 1
rj3 n9__i33__xor1 n5__i33__xor1 500e-3
rj4 n14__net5 n10__net5 1.0774
rj6 n2__i33__i58__net2 n4__i33__i58__net2 1
rj7 n8__net16 n6__net16 1
rj8 n7__i33__i57__net1 n10__i33__i57__net1 1
rj9 n15__i33__i58__net1 n11__i33__i58__net1 846.2e-3
rj10 n11__i33__i58__net1 n13__i33__i58__net1 500e-3
rj11 n2__i33__i57__net2 n4__i33__i57__net2 1
rj12 n8__i33__i58__net2 n6__i33__i58__net2 1
rj13 n15__i33__i57__net1 n11__i33__i57__net1 846.2e-3
rj14 n11__i33__i57__net1 n13__i33__i57__net1 500e-3
rj15 n10__net14 n11__net14 1
rj16 n8__i33__i57__net2 n6__i33__i57__net2 1
rj17 n11__i33__xor1 n12__i33__xor1 1
rj18 n284__clk1pt6g n282__clk1pt6g 500e-3
rj19 n283__clk1pt6g n285__clk1pt6g 500e-3
rj20 n10__net16 n12__net16 1
rj21 n2__i33__i56__net2 n4__i33__i56__net2 1
rj22 n1__vdd n2__vdd 1.0302
rj23 n6__i33__i56__net2 n8__i33__i56__net2 500e-3
rj24 n8__i33__i56__net1 n12__i33__i56__net1 846.2e-3
rj25 n12__i33__i56__net1 n10__i33__i56__net1 500e-3
rj26 n15__i33__xor2 n16__i33__xor2 57.37e-3
rj27 n16__i33__xor2 n10__i33__xor2 654.9e-3
rj28 n16__i33__xor2 n14__i33__xor2 1.0166
rj29 n17__i33__xor1 n15__i33__xor1 1
rj30 n14__i33__i56__net1 n16__i33__i56__net1 500e-3
rj31 n4__i33__i27__net1 n5__i33__i27__net1 1
rj32 n303__clk1pt6g n302__clk1pt6g 500e-3
rj33 n28__clk100m_b n30__clk100m_b 1
rj34 n23__rst n24__rst 1
rj35 n10__i33__i27__net1 n12__i33__i27__net1 1
rj36 n19__net16 n17__net16 1.5676
rj37 n32__rst n31__rst 500e-3
rj39 n19__rst_b n20__rst_b 500e-3
rj40 n4__vdd n5__vdd 1
rj41 n39__clk100m_b n32__clk100m_b 1.3433
rj42 n33__clk100m n34__clk100m 1
rj43 n35__clk100m n27__clk100m 1.7034
rj44 n35__rst n25__rst 1.3216
rj45 n20__net16 n22__net16 500e-3
rj47 n18__net17 n20__net17 392.5e-3
rj48 n20__net17 n21__net17 1.7511
rj49 n21__net17 n10__net17 1.0774
rj50 n20__net17 n13__net17 985.4e-3
rj51 n15__net17 n18__net17 500e-3
rj52 n11__net17 n21__net17 500e-3
rj53 n4__i33__i28__net1 n5__i33__i28__net1 1
rj54 n24__net22 n38__net22 500e-3
rj55 n30__net23 n44__net23 500e-3
rj56 n39__rst n40__rst 1
rj57 n23__net17 n22__net17 500e-3
rj58 n15__vdd n16__vdd 556.2e-3
rj59 n15__vdd n17__vdd 1.1857
rj60 n16__vdd n18__vdd 667.7e-3
rj61 n9__vdd n15__vdd 500e-3
rj62 n11__vdd n16__vdd 500e-3
rj63 n10__i33__i28__net1 n12__i33__i28__net1 1
rj64 n4__net18 n8__net18 500e-3
rj65 n6__net15 n4__net15 1.5676
rj66 n9__i28__net1 n10__i28__net1 1
rj67 n54__clk100m_b n45__clk100m_b 1.1206
rj69 n54__clk100m_b n56__clk100m_b 2.4117
rj70 n42__clk100m_b n45__clk100m_b 500e-3
rj71 n48__rst n47__rst 500e-3
rj73 n31__rst_b n32__rst_b 500e-3
rj74 n29__rst_b n31__rst_b 500e-3
rj75 n53__clk100m_b n46__clk100m_b 1.3433
rj76 n154__clk100m n156__clk100m 1
rj77 n153__clk100m n147__clk100m 1.7034
rj78 n51__rst n41__rst 1.3216
rj79 n9__net18 n10__net18 984.6e-3
rj80 n20__vss n21__vss 700.3e-3
rj81 n21__vss n22__vss 102.9e-3
rj82 n22__vss n2__vss 596.7e-3
rj83 n21__vss n23__vss 1.2532
rj84 n22__vss n24__vss 2.5695
rj85 n9__net15 n7__net15 500e-3
rj87 n30__net16 n32__net16 804.6e-3
rj88 n32__net16 n33__net16 627.2e-3
rj89 n27__net16 n30__net16 500e-3
rj90 n25__net16 n32__net16 500e-3
rj91 out0 n1__out0 767.7e-3
rj92 n4__i33__i26__net1 n5__i33__i26__net1 1
rj93 n59__clk100m_b n62__clk100m_b 500e-3
rj94 n3__net19 n4__net19 1
rj95 n331__clk1pt6g n330__clk1pt6g 1
rj96 n55__rst n56__rst 1
rj97 n36__net16 n35__net16 500e-3
rj98 n333__clk1pt6g n332__clk1pt6g 500e-3
rj99 n21__vdd n27__vdd 1.0562
rj100 n27__vdd n28__vdd 667.7e-3
rj101 n23__vdd n27__vdd 500e-3
rj102 n163__clk100m n164__clk100m 500e-3
rj103 n12__i33__i26__net1 n10__i33__i26__net1 1
rj104 n5__net19 n9__net19 500e-3
rj105 n5__i28__i69__net3 n4__i28__i69__net3 720.7e-3
rj106 n4__i28__i69__net3 n2__i28__i69__net3 218.1e-3
rj107 i28__i69__net2 n10__i28__i69__net2 703.5e-3
rj108 n10__i28__i69__net2 n2__i28__i69__net2 693.8e-3
rj109 n6__i28__i69__net2 n10__i28__i69__net2 500e-3
rj110 n13__net19 n10__net19 1
rj111 n18__net14 n16__net14 1.5676
rj112 n335__clk1pt6g n336__clk1pt6g 1
rj113 n56__net23 n50__net23 838.5e-3
rj114 n337__clk1pt6g n323__clk1pt6g 1.6853
rj115 n64__rst n63__rst 500e-3
rj117 n41__rst_b n42__rst_b 500e-3
rj118 n39__rst_b n41__rst_b 500e-3
rj119 n70__clk100m_b n63__clk100m_b 1.3433
rj120 n169__clk100m n171__clk100m 1
rj121 n341__clk1pt6g n342__clk1pt6g 1
rj122 n37__net29 n33__net29 1.3449
rj124 n33__net29 n15__net29 492.7e-3
rj125 n32__net29 n33__net29 500e-3
rj126 n9__i29__net26 n10__i29__net26 790.6e-3
rj127 n10__i29__net26 n3__i29__net26 986e-3
rj128 n10__i29__net26 n8__i29__net26 553.1e-3
rj129 n168__clk100m n160__clk100m 1.7034
rj130 n67__rst n57__rst 1.3216
rj133 n19__net15 n21__net15 804.6e-3
rj134 n21__net15 n11__net15 127.2e-3
rj135 n16__net15 n19__net15 500e-3
rj136 n14__net15 n21__net15 500e-3
rj137 out1 n5__out1 767.7e-3
rj138 n4__i33__i29__net1 n5__i33__i29__net1 1
rj139 n327__clk1pt6g n346__clk1pt6g 1.6197
rj140 n41__net22 n40__net22 1.2062
rj141 n73__clk100m_b n75__clk100m_b 1
rj142 n3__net38 n4__net38 1
rj143 n353__clk1pt6g n354__clk1pt6g 1
rj144 n71__rst n72__rst 1
rj145 n22__net15 n23__net15 500e-3
rj146 n42__net22 n43__net22 500e-3
rj147 n31__vdd n37__vdd 1.0562
rj148 n37__vdd n38__vdd 667.7e-3
rj149 n33__vdd n37__vdd 500e-3
rj150 n178__clk100m n179__clk100m 500e-3
rj151 n12__i33__i29__net1 n10__i33__i29__net1 1
rj152 i28__i69__net4 n12__i28__i69__net4 698.7e-3
rj153 n12__i28__i69__net4 n2__i28__i69__net4 696.3e-3
rj154 n7__i28__i69__net4 n12__i28__i69__net4 500e-3
rj155 n5__i28__i69__net5 n4__i28__i69__net5 698.7e-3
rj156 n4__i28__i69__net5 n2__i28__i69__net5 209.4e-3
rj157 n5__net38 n9__net38 500e-3
rj158 n13__net38 n10__net38 1
rj159 n6__net13 n4__net13 1.5676
rj160 n355__clk1pt6g n356__clk1pt6g 1
rj161 n65__net23 n61__net23 838.5e-3
rj162 n357__clk1pt6g n347__clk1pt6g 1.6853
rj163 n80__rst n79__rst 500e-3
rj165 n49__rst_b n50__rst_b 500e-3
rj166 n84__clk100m_b n77__clk100m_b 1.3433
rj167 n183__clk100m n184__clk100m 1
rj168 n359__clk1pt6g n360__clk1pt6g 1
rj169 n44__net29 n42__net29 1.3449
rj171 n41__net29 n42__net29 500e-3
rj172 n9__i29__net19 n10__i29__net19 790.6e-3
rj173 n10__i29__net19 n3__i29__net19 986e-3
rj174 n10__i29__net19 n8__i29__net19 553.1e-3
rj175 n185__clk100m n175__clk100m 1.7034
rj176 n83__rst n73__rst 1.3216
rj177 n9__net13 n7__net13 500e-3
rj178 n34__i28__net9 n35__i28__net9 500e-3
rj179 n16__i28__net1 n12__i28__net1 500e-3
rj181 n31__net14 n33__net14 804.6e-3
rj182 n33__net14 n23__net14 127.2e-3
rj183 n28__net14 n31__net14 500e-3
rj184 n26__net14 n33__net14 500e-3
rj185 out2 n5__out2 768.9e-3
rj186 n4__i33__i24__net1 n5__i33__i24__net1 1
rj187 n87__clk100m_b n89__clk100m_b 1
rj188 n3__net39 n4__net39 1
rj189 n372__clk1pt6g n373__clk1pt6g 1
rj190 n87__rst n88__rst 1
rj191 n35__net14 n34__net14 500e-3
rj192 n41__vdd n47__vdd 1.0562
rj193 n47__vdd n48__vdd 667.7e-3
rj194 n43__vdd n47__vdd 500e-3
rj195 n193__clk100m n194__clk100m 500e-3
rj196 n12__i33__i24__net1 n10__i33__i24__net1 1
rj197 n5__net39 n9__net39 500e-3
rj198 n13__net39 n10__net39 1
rj199 n6__net12 n4__net12 1.5676
rj200 n374__clk1pt6g n375__clk1pt6g 1
rj201 n74__net23 n70__net23 838.5e-3
rj202 n376__clk1pt6g n366__clk1pt6g 1.6853
rj203 n96__rst n95__rst 500e-3
rj205 n61__rst_b n62__rst_b 500e-3
rj206 n59__rst_b n61__rst_b 500e-3
rj207 n9__i28__net15 n10__i28__net15 1
rj208 n122__clk100m_b n91__clk100m_b 1.3433
rj209 n199__clk100m n201__clk100m 1
rj210 n378__clk1pt6g n379__clk1pt6g 1
rj211 n53__net29 n51__net29 1.3449
rj213 n50__net29 n51__net29 500e-3
rj214 n9__i29__net9 n10__i29__net9 790.6e-3
rj215 n10__i29__net9 n3__i29__net9 986e-3
rj216 n10__i29__net9 n8__i29__net9 553.1e-3
rj217 n202__clk100m n203__clk100m 1
rj218 n198__clk100m n190__clk100m 1.7034
rj219 n99__rst n89__rst 1.3216
rj220 n9__net12 n7__net12 500e-3
rj222 n19__net13 n21__net13 804.6e-3
rj223 n21__net13 n11__net13 127.2e-3
rj224 n16__net13 n19__net13 500e-3
rj225 n14__net13 n21__net13 500e-3
rj226 out3 n5__out3 768.9e-3
rj227 n4__i33__i25__net1 n5__i33__i25__net1 1
rj228 n125__clk100m_b n126__clk100m_b 1
rj229 n3__net40 n4__net40 1
rj230 i28__net20 n13__i28__net20 1.4972
rj231 n391__clk1pt6g n392__clk1pt6g 1
rj232 n103__rst n104__rst 1
rj233 n23__net13 n22__net13 500e-3
rj234 n51__vdd n57__vdd 1.0562
rj235 n57__vdd n58__vdd 667.7e-3
rj236 n53__vdd n57__vdd 500e-3
rj237 n210__clk100m n211__clk100m 500e-3
rj238 n12__i33__i25__net1 n10__i33__i25__net1 1
rj239 n5__net40 n9__net40 500e-3
rj240 n6__i28__i70__net3 n4__i28__i70__net3 220.7e-3
rj241 n4__i28__i70__net3 n2__i28__i70__net3 218.1e-3
rj242 i28__i70__net2 n13__i28__i70__net2 703.5e-3
rj243 n13__i28__i70__net2 n2__i28__i70__net2 693.8e-3
rj244 n6__i28__i70__net2 n13__i28__i70__net2 500e-3
rj245 n13__net40 n10__net40 1
rj246 n6__net11 n4__net11 1.5676
rj247 n393__clk1pt6g n394__clk1pt6g 1
rj248 n83__net23 n79__net23 838.5e-3
rj249 n395__clk1pt6g n385__clk1pt6g 1.6853
rj250 n112__rst n111__rst 500e-3
rj252 n71__rst_b n72__rst_b 500e-3
rj253 n69__rst_b n71__rst_b 500e-3
rj254 n136__clk100m_b n129__clk100m_b 1.3433
rj255 n216__clk100m n218__clk100m 1
rj256 n397__clk1pt6g n398__clk1pt6g 1
rj257 n62__net29 n60__net29 1.3449
rj259 n59__net29 n60__net29 500e-3
rj260 n9__i29__net16 n10__i29__net16 790.6e-3
rj261 n10__i29__net16 n3__i29__net16 986e-3
rj262 n10__i29__net16 n8__i29__net16 553.1e-3
rj263 n215__clk100m n207__clk100m 1.7034
rj264 n115__rst n105__rst 1.3216
rj265 n9__net11 n7__net11 500e-3
rj267 n19__net12 n21__net12 804.6e-3
rj268 n21__net12 n11__net12 127.2e-3
rj269 n16__net12 n19__net12 500e-3
rj270 n14__net12 n21__net12 500e-3
rj271 out4 n5__out4 770.1e-3
rj272 n17__i28__net20 n19__i28__net20 1.6206
rj273 n37__i28__net9 n36__i28__net9 1.2062
rj274 n4__i33__i23__net1 n5__i33__i23__net1 1
rj275 n141__clk100m_b n139__clk100m_b 1
rj276 n3__net41 n4__net41 1
rj278 n410__clk1pt6g n411__clk1pt6g 1
rj279 n119__rst n120__rst 1
rj280 n23__net12 n22__net12 500e-3
rj281 n61__vdd n67__vdd 1.0562
rj282 n67__vdd n68__vdd 667.7e-3
rj283 n63__vdd n67__vdd 500e-3
rj284 n225__clk100m n226__clk100m 500e-3
rj285 n10__i33__i23__net1 n12__i33__i23__net1 1
rj286 i28__i70__net4 n12__i28__i70__net4 698.7e-3
rj287 n12__i28__i70__net4 n2__i28__i70__net4 696.3e-3
rj288 n7__i28__i70__net4 n12__i28__i70__net4 500e-3
rj289 n5__i28__i70__net5 n4__i28__i70__net5 698.7e-3
rj290 n4__i28__i70__net5 n2__i28__i70__net5 209.4e-3
rj291 n9__net41 n5__net41 500e-3
rj292 n13__net41 n10__net41 1
rj293 n6__net10 n4__net10 1.5676
rj294 n412__clk1pt6g n413__clk1pt6g 1
rj295 n92__net23 n88__net23 838.5e-3
rj296 n414__clk1pt6g n404__clk1pt6g 1.6853
rj297 n128__rst n127__rst 500e-3
rj299 n81__rst_b n82__rst_b 500e-3
rj300 n79__rst_b n81__rst_b 500e-3
rj301 n150__clk100m_b n143__clk100m_b 1.3433
rj302 n231__clk100m n233__clk100m 1
rj303 n416__clk1pt6g n417__clk1pt6g 1
rj304 n71__net29 n69__net29 1.3449
rj306 n68__net29 n69__net29 500e-3
rj307 n9__i29__net29 n10__i29__net29 790.6e-3
rj308 n10__i29__net29 n3__i29__net29 986e-3
rj309 n10__i29__net29 n8__i29__net29 553.1e-3
rj310 n230__clk100m n222__clk100m 1.7034
rj311 n131__rst n121__rst 1.3216
rj312 n9__net10 n7__net10 500e-3
rj313 n34__i28__net3 n35__i28__net3 500e-3
rj314 n15__i28__net15 n11__i28__net15 500e-3
rj316 n19__net11 n21__net11 804.6e-3
rj317 n21__net11 n11__net11 127.2e-3
rj318 n16__net11 n19__net11 500e-3
rj319 n14__net11 n21__net11 500e-3
rj320 out5 n5__out5 768.9e-3
rj321 n4__i33__i30__net1 n5__i33__i30__net1 1
rj322 n153__clk100m_b n155__clk100m_b 1
rj323 n3__net42 n4__net42 1
rj324 n429__clk1pt6g n430__clk1pt6g 1
rj325 n135__rst n136__rst 1
rj326 n23__net11 n22__net11 500e-3
rj327 n71__vdd n77__vdd 1.0562
rj328 n77__vdd n78__vdd 667.7e-3
rj329 n73__vdd n77__vdd 500e-3
rj330 n264__clk100m n265__clk100m 500e-3
rj331 n12__i33__i30__net1 n10__i33__i30__net1 1
rj332 n5__net42 n9__net42 500e-3
rj333 n13__net42 n10__net42 1
rj334 n6__net9 n4__net9 1.5676
rj335 n434__clk1pt6g n432__clk1pt6g 1
rj336 n101__net23 n97__net23 838.5e-3
rj337 n431__clk1pt6g n423__clk1pt6g 1.6853
rj338 n144__rst n143__rst 500e-3
rj339 n9__i28__net17 n10__i28__net17 1
rj341 n91__rst_b n92__rst_b 500e-3
rj342 n89__rst_b n91__rst_b 500e-3
rj343 n164__clk100m_b n157__clk100m_b 1.3433
rj344 n272__clk100m n270__clk100m 1
rj345 n435__clk1pt6g n436__clk1pt6g 1
rj346 n80__net29 n78__net29 1.3449
rj348 n77__net29 n78__net29 500e-3
rj349 n9__i29__net21 n10__i29__net21 790.6e-3
rj350 n10__i29__net21 n3__i29__net21 986e-3
rj351 n10__i29__net21 n8__i29__net21 553.1e-3
rj352 n269__clk100m n261__clk100m 1.7034
rj353 n147__rst n137__rst 1.3216
rj354 n9__net9 n7__net9 500e-3
rj356 n19__net10 n21__net10 804.6e-3
rj357 n21__net10 n11__net10 127.2e-3
rj358 n16__net10 n19__net10 500e-3
rj359 n14__net10 n21__net10 500e-3
rj360 out6 n5__out6 770.1e-3
rj361 n4__i33__i20__net1 n5__i33__i20__net1 1
rj362 n167__clk100m_b n169__clk100m_b 1
rj363 n3__net43 n4__net43 1
rj364 i28__net23 n13__i28__net23 1.4972
rj365 n448__clk1pt6g n449__clk1pt6g 1
rj366 n151__rst n152__rst 1
rj367 n23__net10 n22__net10 500e-3
rj368 n81__vdd n87__vdd 1.0562
rj369 n87__vdd n88__vdd 667.7e-3
rj370 n83__vdd n87__vdd 500e-3
rj371 n279__clk100m n280__clk100m 500e-3
rj372 n12__i33__i20__net1 n10__i33__i20__net1 1
rj373 n5__net43 n9__net43 500e-3
rj374 n6__i28__i71__net3 n4__i28__i71__net3 220.7e-3
rj375 n4__i28__i71__net3 n2__i28__i71__net3 218.1e-3
rj376 i28__i71__net2 n13__i28__i71__net2 703.5e-3
rj377 n13__i28__i71__net2 n2__i28__i71__net2 693.8e-3
rj378 n6__i28__i71__net2 n13__i28__i71__net2 500e-3
rj379 n13__net43 n10__net43 1
rj380 n6__net8 n4__net8 1.5676
rj381 n455__clk1pt6g n456__clk1pt6g 1
rj382 n110__net23 n106__net23 838.5e-3
rj383 n457__clk1pt6g n442__clk1pt6g 1.6853
rj384 n160__rst n159__rst 500e-3
rj386 n101__rst_b n102__rst_b 500e-3
rj387 n99__rst_b n101__rst_b 500e-3
rj388 n178__clk100m_b n171__clk100m_b 1.3433
rj389 n285__clk100m n287__clk100m 1
rj390 n459__clk1pt6g n460__clk1pt6g 1
rj391 n89__net29 n87__net29 1.3449
rj393 n86__net29 n87__net29 500e-3
rj394 n9__i29__net14 n10__i29__net14 790.6e-3
rj395 n10__i29__net14 n3__i29__net14 986e-3
rj396 n10__i29__net14 n8__i29__net14 553.1e-3
rj397 n284__clk100m n276__clk100m 1.7034
rj398 n163__rst n153__rst 1.3216
rj399 n9__net8 n7__net8 500e-3
rj401 n19__net9 n21__net9 804.6e-3
rj402 n21__net9 n11__net9 127.2e-3
rj403 n16__net9 n19__net9 500e-3
rj404 n14__net9 n21__net9 500e-3
rj405 out7 n5__out7 771.4e-3
rj406 n17__i28__net23 n19__i28__net23 1.554
rj407 n37__i28__net3 n36__i28__net3 1.2062
rj408 n4__i33__i21__net1 n5__i33__i21__net1 1
rj410 n184__clk100m_b n185__clk100m_b 500e-3
rj411 n181__clk100m_b n184__clk100m_b 500e-3
rj412 n3__net30 n4__net30 1
rj414 n472__clk1pt6g n473__clk1pt6g 1
rj415 n167__rst n168__rst 1
rj416 n23__net9 n22__net9 500e-3
rj417 n91__vdd n97__vdd 1.0562
rj418 n97__vdd n98__vdd 667.7e-3
rj419 n93__vdd n97__vdd 500e-3
rj420 n294__clk100m n295__clk100m 500e-3
rj421 n10__i33__i21__net1 n12__i33__i21__net1 1
rj422 i28__i71__net4 n12__i28__i71__net4 698.7e-3
rj423 n12__i28__i71__net4 n2__i28__i71__net4 696.3e-3
rj424 n7__i28__i71__net4 n12__i28__i71__net4 500e-3
rj425 n5__i28__i71__net5 n4__i28__i71__net5 698.7e-3
rj426 n4__i28__i71__net5 n2__i28__i71__net5 209.4e-3
rj427 n9__net30 n5__net30 500e-3
rj428 n13__net30 n10__net30 1
rj429 n6__net7 n4__net7 1.5676
rj430 n481__clk1pt6g n482__clk1pt6g 1
rj431 n119__net23 n115__net23 838.5e-3
rj432 n483__clk1pt6g n466__clk1pt6g 1.6853
rj433 n176__rst n175__rst 500e-3
rj435 n111__rst_b n112__rst_b 500e-3
rj436 n109__rst_b n111__rst_b 500e-3
rj438 n303__clk100m n300__clk100m 500e-3
rj439 n194__clk100m_b n187__clk100m_b 1.3433
rj440 n485__clk1pt6g n486__clk1pt6g 1
rj441 n98__net29 n96__net29 1.3449
rj443 n95__net29 n96__net29 500e-3
rj444 n9__i29__net23 n10__i29__net23 790.6e-3
rj445 n10__i29__net23 n3__i29__net23 986e-3
rj446 n10__i29__net23 n8__i29__net23 553.1e-3
rj447 n299__clk100m n291__clk100m 1.7034
rj448 n179__rst n169__rst 1.3216
rj449 n9__net7 n7__net7 500e-3
rj450 n34__i28__net12 n35__i28__net12 500e-3
rj451 n15__i28__net17 n11__i28__net17 500e-3
rj453 n19__net8 n21__net8 806e-3
rj454 n21__net8 n11__net8 127.2e-3
rj455 n16__net8 n19__net8 500e-3
rj456 n14__net8 n21__net8 500e-3
rj457 out8 n5__out8 768.9e-3
rj458 n4__i33__i19__net1 n5__i33__i19__net1 1
rj459 n197__clk100m_b n199__clk100m_b 1
rj460 n3__net31 n4__net31 1
rj461 n498__clk1pt6g n499__clk1pt6g 1
rj462 n183__rst n184__rst 1
rj463 n23__net8 n22__net8 500e-3
rj464 n101__vdd n107__vdd 1.0562
rj465 n107__vdd n108__vdd 667.7e-3
rj466 n103__vdd n107__vdd 500e-3
rj467 n310__clk100m n311__clk100m 500e-3
rj468 n12__i33__i19__net1 n10__i33__i19__net1 1
rj469 n5__net31 n6__net31 1
rj470 n13__net31 n10__net31 1
rj471 n6__net6 n4__net6 1.5676
rj472 n505__clk1pt6g n506__clk1pt6g 1
rj473 n128__net23 n124__net23 838.5e-3
rj474 n507__clk1pt6g n492__clk1pt6g 1.6853
rj475 n9__i28__net19 n10__i28__net19 1
rj476 n192__rst n191__rst 500e-3
rj478 n121__rst_b n122__rst_b 500e-3
rj479 n119__rst_b n121__rst_b 500e-3
rj480 n208__clk100m_b n201__clk100m_b 1.3433
rj481 n318__clk100m n316__clk100m 1
rj482 n16__i28__net2 n19__i28__net2 109.6e-3
rj483 n19__i28__net2 n20__i28__net2 285.6e-3
rj484 n20__i28__net2 n10__i28__net2 264.6e-3
rj485 n19__i28__net2 n18__i28__net2 87.79e-3
rj486 n20__i28__net2 n14__i28__net2 82.88e-3
rj487 n20__i28__net2 n12__i28__net2 104.7e-3
rj488 n514__clk1pt6g n515__clk1pt6g 1
rj489 n109__net29 n105__net29 1.3449
rj491 n104__net29 n105__net29 500e-3
rj492 n9__i29__net25 n10__i29__net25 790.6e-3
rj493 n10__i29__net25 n3__i29__net25 986e-3
rj494 n10__i29__net25 n8__i29__net25 553.1e-3
rj495 n315__clk100m n307__clk100m 1.7034
rj496 n195__rst n185__rst 1.3216
rj497 n9__net6 n7__net6 500e-3
rj499 n19__net7 n21__net7 804.6e-3
rj500 n21__net7 n11__net7 127.2e-3
rj501 n16__net7 n19__net7 500e-3
rj502 n14__net7 n21__net7 500e-3
rj503 out9 n5__out9 770.1e-3
rj504 n4__i33__i22__net1 n5__i33__i22__net1 1
rj505 n211__clk100m_b n213__clk100m_b 1
rj506 n3__net32 n4__net32 1
rj507 i28__net26 n13__i28__net26 1.5761
rj508 n522__clk1pt6g n523__clk1pt6g 1
rj509 n199__rst n200__rst 1
rj510 n23__net7 n22__net7 500e-3
rj511 n24__i28__net7 n21__i28__net7 1.7832
rj512 n111__vdd n117__vdd 1.0562
rj513 n117__vdd n118__vdd 667.7e-3
rj514 n113__vdd n117__vdd 500e-3
rj515 n325__clk100m n326__clk100m 1
rj516 n12__i33__i22__net1 n10__i33__i22__net1 1
rj517 n6__i28__i72__net3 n4__i28__i72__net3 220.7e-3
rj518 n4__i28__i72__net3 n2__i28__i72__net3 218.1e-3
rj519 n5__net32 n9__net32 500e-3
rj520 i28__i72__net2 n13__i28__i72__net2 703.5e-3
rj521 n13__i28__i72__net2 n2__i28__i72__net2 693.8e-3
rj522 n6__i28__i72__net2 n13__i28__i72__net2 500e-3
rj523 n13__net32 n10__net32 1
rj524 n26__i28__net7 n25__i28__net7 500e-3
rj525 n20__net5 n18__net5 1.5676
rj526 n531__clk1pt6g n532__clk1pt6g 1
rj527 n137__net23 n133__net23 838.5e-3
rj528 n533__clk1pt6g n516__clk1pt6g 1.6853
rj529 n208__rst n207__rst 500e-3
rj530 n9__i28__i50__net1 n8__i28__i50__net1 741.7e-3
rj531 n14__i28__i50__net1 n7__i28__i50__net1 1.0724
rj533 n131__rst_b n132__rst_b 500e-3
rj534 n129__rst_b n131__rst_b 500e-3
rj535 n222__clk100m_b n215__clk100m_b 1.3433
rj536 n331__clk100m n333__clk100m 1
rj537 n540__clk1pt6g n541__clk1pt6g 1
rj538 n118__net29 n114__net29 1.3449
rj540 n113__net29 n114__net29 500e-3
rj541 n9__i29__net12 n10__i29__net12 790.6e-3
rj542 n10__i29__net12 n3__i29__net12 986e-3
rj543 n10__i29__net12 n8__i29__net12 553.1e-3
rj544 n330__clk100m n322__clk100m 1.7034
rj545 n211__rst n201__rst 1.3216
rj546 n23__net5 n21__net5 500e-3
rj548 n19__net6 n21__net6 804.6e-3
rj549 n21__net6 n11__net6 127.2e-3
rj550 n16__net6 n19__net6 500e-3
rj551 n14__net6 n21__net6 500e-3
rj552 out10 n5__out10 770.1e-3
rj553 n17__i28__net26 n19__i28__net26 1.554
rj554 n37__i28__net12 n36__i28__net12 1.2062
rj555 n4__i33__i17__net1 n5__i33__i17__net1 1
rj556 n69__net22 n70__net22 500e-3
rj557 n225__clk100m_b n227__clk100m_b 1
rj558 n3__net33 n4__net33 1
rj560 n549__clk1pt6g n548__clk1pt6g 1
rj561 n215__rst n217__rst 1
rj562 n23__net6 n22__net6 500e-3
rj563 n121__vdd n127__vdd 1.0562
rj564 n127__vdd n128__vdd 667.7e-3
rj565 n123__vdd n127__vdd 500e-3
rj566 n338__clk100m n339__clk100m 500e-3
rj567 n10__i33__i17__net1 n12__i33__i17__net1 1
rj568 i28__i72__net4 n16__i28__i72__net4 698.7e-3
rj569 n16__i28__i72__net4 n2__i28__i72__net4 696.3e-3
rj570 n7__i28__i72__net4 n16__i28__i72__net4 500e-3
rj571 n6__i28__i72__net5 n4__i28__i72__net5 198.7e-3
rj572 n4__i28__i72__net5 n2__i28__i72__net5 209.4e-3
rj573 n5__net33 n6__net33 1
rj574 n13__net33 n10__net33 1
rj575 n6__net4 n4__net4 1.5676
rj576 n554__clk1pt6g n552__clk1pt6g 1
rj577 n146__net23 n142__net23 838.5e-3
rj578 n551__clk1pt6g n542__clk1pt6g 1.6853
rj579 n219__rst n218__rst 500e-3
rj580 i28__i53__net4 n16__i28__i53__net4 696.3e-3
rj581 n16__i28__i53__net4 n2__i28__i53__net4 698.7e-3
rj582 n7__i28__i53__net4 n16__i28__i53__net4 500e-3
rj583 n6__i28__i53__net5 n4__i28__i53__net5 209.4e-3
rj584 n4__i28__i53__net5 n2__i28__i53__net5 198.7e-3
rj586 n136__rst_b n137__rst_b 500e-3
rj587 n134__rst_b n136__rst_b 500e-3
rj588 n233__clk100m_b n229__clk100m_b 1.3433
rj589 n344__clk100m n346__clk100m 1
rj590 n555__clk1pt6g n556__clk1pt6g 1
rj591 n125__net29 n123__net29 1.3449
rj592 n123__net29 n122__net29 500e-3
rj593 n9__i29__net6 n10__i29__net6 790.6e-3
rj594 n10__i29__net6 n3__i29__net6 986e-3
rj595 n10__i29__net6 n8__i29__net6 553.1e-3
rj596 n343__clk100m n337__clk100m 1.7034
rj597 n222__rst n216__rst 1.3216
rj598 n9__net4 n7__net4 500e-3
rj599 n34__i28__net13 n35__i28__net13 500e-3
rj600 n15__i28__net19 n11__i28__net19 500e-3
rj602 n31__net5 n33__net5 804.6e-3
rj603 n33__net5 n34__net5 627.2e-3
rj604 n28__net5 n31__net5 500e-3
rj605 n26__net5 n33__net5 500e-3
rj606 out11 n5__out11 770.1e-3
rj607 n4__i33__i18__net1 n5__i33__i18__net1 1
rj608 n565__clk1pt6g n562__clk1pt6g 500e-3
rj609 n234__clk100m_b n237__clk100m_b 1
rj610 n3__net34 n4__net34 1
rj611 n571__clk1pt6g n573__clk1pt6g 1
rj612 n226__rst n228__rst 1
rj613 n37__net5 n40__net5 1
rj614 n131__vdd n137__vdd 1.0562
rj615 n137__vdd n138__vdd 667.7e-3
rj616 n133__vdd n137__vdd 500e-3
rj617 n348__clk100m n349__clk100m 500e-3
rj618 n12__i33__i18__net1 n10__i33__i18__net1 1
rj619 n73__net22 n72__net22 706e-3
rj620 n5__net34 n9__net34 500e-3
rj621 n12__net34 n13__net34 1
rj622 n6__net3 n4__net3 1.5676
rj623 n577__clk1pt6g n575__clk1pt6g 1
rj624 n155__net23 n151__net23 838.5e-3
rj625 n572__clk1pt6g n550__clk1pt6g 1.1197
rj626 i28__i53__net2 n13__i28__i53__net2 693.8e-3
rj627 n13__i28__i53__net2 n2__i28__i53__net2 703.5e-3
rj628 n6__i28__i53__net2 n13__i28__i53__net2 500e-3
rj629 n574__clk1pt6g n563__clk1pt6g 1.6853
rj630 n6__i28__i53__net3 n4__i28__i53__net3 218.1e-3
rj631 n4__i28__i53__net3 n2__i28__i53__net3 220.7e-3
rj632 n9__i28__net5 n10__i28__net5 500e-3
rj633 n229__rst n230__rst 500e-3
rj635 n143__rst_b n144__rst_b 500e-3
rj636 n141__rst_b n143__rst_b 500e-3
rj637 n239__clk100m_b n236__clk100m_b 1.3433
rj638 n351__clk100m n353__clk100m 1
rj639 n578__clk1pt6g n584__clk1pt6g 1
rj640 n133__net29 n131__net29 1.3449
rj642 n130__net29 n131__net29 500e-3
rj643 n9__i29__net34 n13__i29__net34 790.6e-3
rj644 n13__i29__net34 n3__i29__net34 986e-3
rj645 n13__i29__net34 n8__i29__net34 553.1e-3
rj646 n350__clk100m n347__clk100m 1.7034
rj647 n233__rst n227__rst 1.3216
rj648 n9__net3 n7__net3 500e-3
rj650 n19__net4 n21__net4 804.6e-3
rj651 n21__net4 n11__net4 127.2e-3
rj652 n16__net4 n19__net4 500e-3
rj653 n14__net4 n21__net4 500e-3
rj654 out12 n5__out12 770.1e-3
rj655 n5__i33__i16__net1 n8__i33__i16__net1 1
rj656 n27__i28__net7 n28__i28__net7 1
rj657 n75__net22 n74__net22 500e-3
rj658 n240__clk100m_b n248__clk100m_b 1
rj659 n18__i28__net11 n13__i28__net11 1.0021
rj660 n3__net35 n11__net35 1
rj661 n587__clk1pt6g n616__clk1pt6g 1
rj662 n237__rst n253__rst 1
rj663 n22__net4 n25__net4 1
rj664 n141__vdd n674__vdd 1.0562
rj665 n674__vdd n265__vdd 667.7e-3
rj666 n143__vdd n674__vdd 500e-3
rj667 n355__clk100m n365__clk100m 500e-3
rj668 n10__i33__i16__net1 n12__i33__i16__net1 1
rj669 n6__i28__i51__net3 n4__i28__i51__net3 220.7e-3
rj670 n4__i28__i51__net3 n2__i28__i51__net3 218.1e-3
rj671 i28__i51__net2 n13__i28__i51__net2 703.5e-3
rj672 n13__i28__i51__net2 n2__i28__i51__net2 693.8e-3
rj673 n6__i28__i51__net2 n13__i28__i51__net2 500e-3
rj674 n4__net35 n12__net35 500e-3
rj675 n10__net35 n13__net35 1
rj676 n7__net2 n4__net2 1.5676
rj677 i28__i52__net4 n16__i28__i52__net4 696.3e-3
rj678 n16__i28__i52__net4 n2__i28__i52__net4 698.7e-3
rj679 n7__i28__i52__net4 n16__i28__i52__net4 500e-3
rj680 n6__i28__i52__net5 n4__i28__i52__net5 209.4e-3
rj681 n4__i28__i52__net5 n2__i28__i52__net5 198.7e-3
rj682 n590__clk1pt6g n617__clk1pt6g 1
rj683 n161__net23 n160__net23 838.5e-3
rj684 n589__clk1pt6g n585__clk1pt6g 1.6853
rj685 n239__rst n254__rst 1
rj687 n151__rst_b n152__rst_b 500e-3
rj688 n147__rst_b n151__rst_b 500e-3
rj689 n243__clk100m_b n242__clk100m_b 1.3433
rj690 n357__clk100m n366__clk100m 1
rj691 n592__clk1pt6g n618__clk1pt6g 1
rj692 n138__net29 n145__net29 1.3449
rj693 n145__net29 n146__net29 500e-3
rj694 n137__net29 n145__net29 500e-3
rj695 n9__i29__net18 n13__i29__net18 790.6e-3
rj696 n13__i29__net18 n3__i29__net18 986e-3
rj697 n13__i29__net18 n8__i29__net18 553.1e-3
rj698 n356__clk100m n354__clk100m 1.7034
rj699 n242__rst n238__rst 1.3216
rj700 n18__net2 n6__net2 500e-3
rj701 n17__i28__net11 n19__i28__net11 1.1206
rj703 n19__net3 n21__net3 804.6e-3
rj704 n21__net3 n22__net3 627.2e-3
rj705 n13__net3 n19__net3 500e-3
rj706 n11__net3 n21__net3 500e-3
rj707 n37__i28__net13 n36__i28__net13 706.2e-3
rj708 out13 n7__out13 768.9e-3
rj709 n593__clk1pt6g n619__clk1pt6g 500e-3
rj710 n11__i33__i0__net1 n5__i33__i0__net1 1
rj711 n244__clk100m_b n249__clk100m_b 1
rj712 n38__i28__net13 n39__i28__net13 500e-3
rj713 n3__net36 n11__net36 1
rj714 n620__clk1pt6g n596__clk1pt6g 1
rj715 n246__rst n255__rst 1
rj716 n16__net3 n23__net3 1
rj717 n149__vdd n675__vdd 1.0562
rj718 n675__vdd n263__vdd 667.7e-3
rj719 n151__vdd n675__vdd 500e-3
rj720 n77__net22 n76__net22 706e-3
rj721 n360__clk100m n367__clk100m 500e-3
rj722 i28__i51__net4 n16__i28__i51__net4 698.7e-3
rj723 n16__i28__i51__net4 n2__i28__i51__net4 696.3e-3
rj724 n7__i28__i51__net4 n16__i28__i51__net4 500e-3
rj725 n6__i28__i51__net5 n4__i28__i51__net5 198.7e-3
rj726 n4__i28__i51__net5 n2__i28__i51__net5 209.4e-3
rj727 n9__i33__i0__net1 n12__i33__i0__net1 1
rj728 n12__net36 n4__net36 500e-3
rj729 n597__clk1pt6g n588__clk1pt6g 1.1197
rj730 i28__i52__net2 n13__i28__i52__net2 693.8e-3
rj731 n13__i28__i52__net2 n2__i28__i52__net2 703.5e-3
rj732 n6__i28__i52__net2 n13__i28__i52__net2 500e-3
rj733 n6__i28__i52__net3 n4__i28__i52__net3 218.1e-3
rj734 n4__i28__i52__net3 n2__i28__i52__net3 220.7e-3
rj735 n10__net36 n13__net36 1
rj736 n8__i33__d0 n13__i33__d0 1.0678
rj737 n13__i33__d0 n3__i33__d0 10.3345
rj738 n10__i33__d0 n13__i33__d0 500e-3
rj739 n621__clk1pt6g n599__clk1pt6g 1
rj740 n165__net23 n164__net23 838.5e-3
rj741 n598__clk1pt6g n594__clk1pt6g 1.6853
rj742 n248__rst n256__rst 1
rj744 n154__rst_b n155__rst_b 500e-3
rj745 n149__rst_b n154__rst_b 500e-3
rj746 n247__clk100m_b n246__clk100m_b 1.3433
rj747 n362__clk100m n368__clk100m 1
rj748 n601__clk1pt6g n622__clk1pt6g 1
rj749 n140__net29 n147__net29 1.3449
rj750 n147__net29 n139__net29 500e-3
rj751 n9__i29__net13 n13__i29__net13 790.6e-3
rj752 n13__i29__net13 n3__i29__net13 986e-3
rj753 n13__i29__net13 n8__i29__net13 553.1e-3
rj754 n361__clk100m n359__clk100m 1.7034
rj755 n251__rst n247__rst 1.3208
rj756 n15__i28__net5 n11__i28__net5 500e-3
rj758 n19__net2 n21__net2 794.3e-3
rj760 n21__net2 n23__net2 622.7e-3
rj761 n12__net2 n19__net2 500e-3
rj762 n10__net2 n21__net2 500e-3
rj763 out14 n7__out14 770.1e-3
rj764 n23__i28__net6 n22__i28__net6 500e-3
rj765 n21__i28__net6 n24__i28__net6 500e-3
rj766 n3__net37 n11__net37 1
rj767 n604__clk1pt6g n623__clk1pt6g 1
rj768 n15__net2 n24__net2 1
rj769 n253__vdd n676__vdd 1.0562
rj770 n676__vdd n261__vdd 667.7e-3
rj771 n255__vdd n676__vdd 500e-3
rj772 n364__clk100m n369__clk100m 500e-3
rj773 n12__net37 n4__net37 500e-3
rj774 n10__net37 n13__net37 1
rj775 n624__clk1pt6g n606__clk1pt6g 1
rj776 n169__net23 n168__net23 838.5e-3
rj777 n605__clk1pt6g n602__clk1pt6g 1.6853
rj778 n608__clk1pt6g n625__clk1pt6g 1
rj779 n142__net29 n148__net29 1.3449
rj780 n148__net29 n149__net29 500e-3
rj781 n141__net29 n148__net29 500e-3
rj782 n9__i29__net7 n13__i29__net7 790.6e-3
rj783 n13__i29__net7 n3__i29__net7 986e-3
rj784 n13__i29__net7 n8__i29__net7 553.1e-3
rj785 out15 n7__out15 770.1e-3
rj786 n171__net23 n174__net23 1.2049
rj787 n174__net23 n175__net23 645.9e-3
rj788 n175__net23 n176__net23 645.9e-3
rj789 n176__net23 n177__net23 645.9e-3
rj790 n177__net23 n178__net23 645.9e-3
rj791 n178__net23 n179__net23 689.4e-3
rj792 n179__net23 n180__net23 676.4e-3
rj793 n180__net23 n181__net23 645.9e-3
rj794 n181__net23 n182__net23 645.9e-3
rj795 n182__net23 n183__net23 645.9e-3
rj796 n183__net23 n184__net23 645.9e-3
rj797 n184__net23 n185__net23 645.9e-3
rj798 n185__net23 n186__net23 645.9e-3
rj799 n186__net23 n187__net23 645.9e-3
rj800 n187__net23 n51__net23 637.5e-3
rj801 n51__net23 n48__net23 575.4e-3
rj802 n174__net23 n166__net23 555.5e-3
rj803 n175__net23 n162__net23 555.5e-3
rj804 n176__net23 n158__net23 555.5e-3
rj805 n177__net23 n149__net23 555.5e-3
rj806 n178__net23 n140__net23 555.5e-3
rj807 n179__net23 n131__net23 555.5e-3
rj808 n180__net23 n122__net23 555.5e-3
rj809 n181__net23 n113__net23 555.5e-3
rj810 n182__net23 n104__net23 555.5e-3
rj811 n183__net23 n95__net23 555.5e-3
rj812 n184__net23 n86__net23 555.5e-3
rj813 n185__net23 n77__net23 555.5e-3
rj814 n186__net23 n68__net23 555.5e-3
rj815 n187__net23 n59__net23 555.5e-3
rj816 n298__vdd n604__vdd 874.5e-3
rj817 n604__vdd n650__vdd 1.2226
rj818 n611__clk1pt6g n626__clk1pt6g 1
rj819 n14__net20 net20 1
rj820 n6__net20 n15__net20 1
rj821 n627__clk1pt6g n614__clk1pt6g 1
rj822 n173__net23 n172__net23 838.5e-3
rj823 n612__clk1pt6g n610__clk1pt6g 1.6853
rj824 n615__clk1pt6g n628__clk1pt6g 1
rj825 n144__net29 n150__net29 1.3449
rj826 n150__net29 n151__net29 500e-3
rj827 n143__net29 n150__net29 500e-3
rj828 n387__vss n78__vss 1.0676
rj829 n484__vss n86__vss 1.0676
rj830 n13__net20 n16__net20 500e-3
rj831 n12__net21 n10__net21 2.544
rj834 n9__net28 n7__net28 1.3098
rj835 n10__net20 n17__net20 1.0343
rj836 n17__net20 n7__net20 500e-3
rk1 n7__net14 n5__net14 31.2929
rk2 n5__net14 n8__net14 75.0034
rk3 n10__net5 n2__net5 502.3e-3
rk4 n8__i33__i58__net1 n9__i33__i58__net1 1.275e-3
rk5 n3__i33__i58__net1 n10__i33__i58__net1 1.275e-3
rk6 n9__i33__i58__net1 n10__i33__i58__net1 16.93e-3
rk7 n5__i33__xor1 n7__i33__xor1 855.5e-3
rk8 n7__i33__xor1 n8__i33__xor1 31.3563
rk9 n6__i33__xor1 n7__i33__xor1 75
rk10 i33__i58__net2 n2__i33__i58__net2 75.2365
rk11 n2__i33__i58__net2 n3__i33__i58__net2 31.078
rk13 n13__i33__i58__net1 n5__i33__i58__net1 2.737e-3
rk14 n14__i33__i58__net1 n15__i33__i58__net1 75.1305
rk15 n15__i33__i58__net1 n16__i33__i58__net1 31.1739
rk16 n5__net16 n6__net16 31.2929
rk17 n6__net16 n7__net16 75.0034
rk18 n2__net17 n10__net17 3.577e-3
rk19 n7__i33__i57__net1 n8__i33__i57__net1 1.275e-3
rk20 n3__i33__i57__net1 n9__i33__i57__net1 1.275e-3
rk21 n8__i33__i57__net1 n9__i33__i57__net1 16.93e-3
rk22 n8__net5 n14__net5 191.3e-3
rk23 n14__net5 n3__net5 3.265e-3
rk24 i33__i57__net2 n2__i33__i57__net2 31.078
rk25 n2__i33__i57__net2 n3__i33__i57__net2 75.2365
rk26 n5__i33__i58__net2 n6__i33__i58__net2 75.1305
rk27 n6__i33__i58__net2 n7__i33__i58__net2 31.1673
rk29 n13__i33__i57__net1 n5__i33__i57__net1 3.011e-3
rk30 n14__i33__i57__net1 n15__i33__i57__net1 31.1739
rk31 n15__i33__i57__net1 n16__i33__i57__net1 75.1305
rk32 n9__net17 n11__net17 191.3e-3
rk33 n11__net17 n3__net17 3.265e-3
rk34 net14 n10__net14 2.822e-3
rk35 n5__i33__i57__net2 n6__i33__i57__net2 31.1673
rk36 n6__i33__i57__net2 n7__i33__i57__net2 75.1305
rk37 n11__i33__xor1 n3__i33__xor1 2.822e-3
rk38 n127__clk1pt6g n282__clk1pt6g 500e-3
rk39 n20__clk1pt6g n283__clk1pt6g 500e-3
rk40 n10__i33__xor2 n12__i33__xor2 1.8099
rk41 n12__i33__xor2 n13__i33__xor2 75.3563
rk42 n11__i33__xor2 n12__i33__xor2 31
rk43 net16 n12__net16 2.822e-3
rk44 i33__i56__net2 n2__i33__i56__net2 75.1305
rk45 n2__i33__i56__net2 n3__i33__i56__net2 31.1673
rk46 n7__i33__i56__net1 n8__i33__i56__net1 75.1305
rk47 n8__i33__i56__net1 n9__i33__i56__net1 31.1739
rk48 n5__i33__i56__net2 n6__i33__i56__net2 75.2365
rk49 n6__i33__i56__net2 n7__i33__i56__net2 31.078
rk50 i33__xor2 n14__i33__xor2 191.3e-3
rk51 n14__i33__xor2 n6__i33__xor2 3.265e-3
rk52 n2__i33__i56__net1 n10__i33__i56__net1 2.737e-3
rk54 n2__i33__d0 n3__i33__d0 791e-3
rk55 n2__i33__d0 n4__i33__d0 31.3563
rk56 i33__d0 n2__i33__d0 75
rk57 n8__i33__xor2 n15__i33__xor2 502.3e-3
rk58 n14__i33__xor1 n15__i33__xor1 31.2947
rk59 n15__i33__xor1 n16__i33__xor1 75.0034
rk60 n3__i33__i56__net1 n13__i33__i56__net1 1.275e-3
rk61 n14__i33__i56__net1 n15__i33__i56__net1 1.275e-3
rk62 n13__i33__i56__net1 n15__i33__i56__net1 16.93e-3
rk63 n6__i33__i27__net1 n4__i33__i27__net1 6.34e-3
rk64 n7__i33__i27__net1 n8__i33__i27__net1 6.314e-3
rk65 n6__i33__i27__net1 n8__i33__i27__net1 26.25e-3
rk66 n2__i33__i27__net1 n7__i33__i27__net1 45
rk67 n226__clk1pt6g n302__clk1pt6g 503.3e-3
rk68 n3__clk100m_b n28__clk100m_b 2.658e-3
rk70 n32__clk100m_b clk100m_b 19.54e-3
rk71 n27__clk100m n2__clk100m 2.493e-3
rk72 n14__net16 n16__net16 2.601e-3
rk73 n17__net16 n18__net16 2.601e-3
rk74 n14__net16 n18__net16 15.28e-3
rk75 n15__net16 n16__net16 31
rk76 n22__rst n23__rst 6.895e-3
rk77 n21__rst n22__rst 75
rk78 n3__rst n25__rst 3.265e-3
rk79 n9__i33__i27__net1 n10__i33__i27__net1 75.3656
rk80 n10__i33__i27__net1 n11__i33__i27__net1 31.0029
rk81 n3__i33__i27__x n5__i33__i27__x 78.72e-3
rk82 n5__i33__i27__x n6__i33__i27__x 75.2443
rk83 n5__i33__i27__x n7__i33__i27__x 31.3568
rk85 n22__rst_b n3__rst_b 3.265e-3
rk86 n19__rst_b n22__rst_b 500e-3
rk87 n3__clk100m n35__clk100m 4.773e-3
rk88 n5__clk100m n34__clk100m 2.658e-3
rk90 n39__clk100m_b n5__clk100m_b 3.265e-3
rk91 n32__rst n34__rst 13.53e-3
rk92 n34__rst n35__rst 349.6e-3
rk94 n33__rst n34__rst 31
rk95 n12__net17 n13__net17 31.1796
rk96 n13__net17 n14__net17 75.3564
rk97 n20__net16 n19__net16 672.8e-3
rk98 n19__net16 n21__net16 75.0029
rk99 n15__net17 n17__net17 13.27e-3
rk100 n16__net17 n17__net17 31
rk101 n8__vdd n9__vdd 3.382e-3
rk102 n7__vdd n8__vdd 75
rk103 n6__i33__i28__net1 n5__i33__i28__net1 6.34e-3
rk104 n7__i33__i28__net1 n8__i33__i28__net1 6.314e-3
rk105 n6__i33__i28__net1 n8__i33__i28__net1 26.25e-3
rk106 n2__i33__i28__net1 n7__i33__i28__net1 45
rk107 n13__net22 n14__net22 8.2208
rk108 n14__net22 n15__net22 282.7e-3
rk109 n15__net22 n16__net22 283.1e-3
rk110 n16__net22 n17__net22 283.1e-3
rk111 n17__net22 n18__net22 283.1e-3
rk112 n18__net22 n19__net22 283.1e-3
rk113 n19__net22 n20__net22 283.1e-3
rk114 n20__net22 n21__net22 263.7e-3
rk115 n21__net22 n22__net22 19.0265
rk116 n14__net22 n23__net22 19.0265
rk117 n14__net22 n24__net22 559.2e-3
rk118 n15__net22 n25__net22 19.0195
rk119 n15__net22 n26__net22 8.2139
rk120 n16__net22 n27__net22 19.0195
rk121 n16__net22 n28__net22 8.2139
rk122 n17__net22 n29__net22 19.0195
rk123 n17__net22 n30__net22 8.2139
rk124 n18__net22 n31__net22 19.0195
rk125 n18__net22 n32__net22 8.2139
rk126 n19__net22 n33__net22 19.0195
rk127 n19__net22 n34__net22 8.2139
rk128 n20__net22 n35__net22 19.0195
rk129 n20__net22 n36__net22 8.2139
rk130 n21__net22 n37__net22 8.2215
rk131 n8__clk100m_b n42__clk100m_b 2.658e-3
rk133 n19__net23 n20__net23 8.2208
rk134 n20__net23 n21__net23 282.7e-3
rk135 n21__net23 n22__net23 283.1e-3
rk136 n22__net23 n23__net23 283.1e-3
rk137 n23__net23 n24__net23 283.1e-3
rk138 n24__net23 n25__net23 283.1e-3
rk139 n25__net23 n26__net23 283.1e-3
rk140 n26__net23 n27__net23 263.7e-3
rk141 n27__net23 n28__net23 19.0268
rk142 n20__net23 n29__net23 19.0265
rk143 n20__net23 n30__net23 559.2e-3
rk144 n21__net23 n31__net23 19.0195
rk145 n21__net23 n32__net23 8.2139
rk146 n22__net23 n33__net23 19.0195
rk147 n22__net23 n34__net23 8.2139
rk148 n23__net23 n35__net23 19.0195
rk149 n23__net23 n36__net23 8.2139
rk150 n24__net23 n37__net23 19.0195
rk151 n24__net23 n38__net23 8.2139
rk152 n25__net23 n39__net23 19.0195
rk153 n25__net23 n40__net23 8.2139
rk154 n26__net23 n41__net23 19.0195
rk155 n26__net23 n42__net23 8.2139
rk156 n27__net23 n43__net23 8.2212
rk157 n46__clk100m_b n6__clk100m_b 19.54e-3
rk158 n10__vdd n11__vdd 2.601e-3
rk159 n13__vdd n14__vdd 2.601e-3
rk160 n10__vdd n14__vdd 15.28e-3
rk161 n12__vdd n13__vdd 31
rk162 n147__clk100m n7__clk100m 2.493e-3
rk163 net15 n3__net15 2.601e-3
rk164 n4__net15 n5__net15 2.601e-3
rk165 net15 n5__net15 15.28e-3
rk166 n2__net15 n3__net15 31
rk167 n38__rst n39__rst 6.895e-3
rk168 n37__rst n38__rst 75
rk169 n1__vss n2__vss 18.9572
rk170 n2__vss n3__vss 342.1e-3
rk171 n3__vss n4__vss 359.5e-3
rk172 n4__vss n5__vss 359.5e-3
rk173 n5__vss n6__vss 359.5e-3
rk174 n6__vss n7__vss 359.5e-3
rk175 n7__vss n8__vss 359.5e-3
rk176 n8__vss n9__vss 359.5e-3
rk177 n9__vss n10__vss 359.5e-3
rk178 n10__vss n11__vss 21.1001
rk179 n3__vss n12__vss 18.9871
rk180 n4__vss n13__vss 18.9871
rk181 n5__vss n14__vss 18.9871
rk182 n6__vss n15__vss 18.9871
rk183 n7__vss n16__vss 18.9871
rk184 n8__vss n17__vss 18.9871
rk185 n9__vss n18__vss 18.9871
rk186 n10__vss n19__vss 18.9816
rk187 n23__net17 n25__net17 6.895e-3
rk188 n24__net17 n25__net17 75
rk189 n8__rst n41__rst 3.265e-3
rk190 n9__i33__i28__net1 n10__i33__i28__net1 75.3656
rk191 n10__i33__i28__net1 n11__i33__i28__net1 31.0029
rk192 n4__net18 n5__net18 852.8e-3
rk193 n5__net18 n6__net18 75.1291
rk194 n5__net18 n7__net18 31.2567
rk195 n3__i33__i28__x n5__i33__i28__x 78.72e-3
rk196 n5__i33__i28__x n6__i33__i28__x 75.2443
rk197 n5__i33__i28__x n7__i33__i28__x 31.3568
rk198 n15__net29 n16__net29 2.107
rk199 n16__net29 n17__net29 283.1e-3
rk200 n17__net29 n18__net29 283.1e-3
rk201 n18__net29 n19__net29 263.7e-3
rk202 n19__net29 n20__net29 9.8462
rk203 n16__net29 n21__net29 9.8389
rk204 n16__net29 n22__net29 4.7276
rk205 n17__net29 n23__net29 9.8389
rk206 n17__net29 n24__net29 4.7276
rk207 n18__net29 n25__net29 9.8389
rk208 n18__net29 n26__net29 4.7276
rk209 n19__net29 n27__net29 4.7349
rk211 n29__rst_b n6__rst_b 9.796e-3
rk212 n8__clk100m n153__clk100m 4.773e-3
rk213 n10__clk100m n154__clk100m 2.658e-3
rk215 n53__clk100m_b n10__clk100m_b 3.265e-3
rk216 n5__i28__net1 n9__i28__net1 45.0968
rk218 n48__rst n50__rst 13.53e-3
rk219 n50__rst n51__rst 349.6e-3
rk221 n49__rst n50__rst 31
rk222 n24__net16 n25__net16 31.2956
rk223 n25__net16 n26__net16 75.2544
rk224 n7__net15 n6__net15 672.8e-3
rk225 n6__net15 n8__net15 75.0029
rk226 i28__i69__net3 n2__i28__i69__net3 38.0375
rk228 n2__i28__i69__net2 n4__i28__i69__net2 42.96e-3
rk229 n3__i28__i69__net2 n4__i28__i69__net2 15.5
rk230 n27__net16 n29__net16 13.27e-3
rk231 n28__net16 n29__net16 31
rk232 n20__vdd n21__vdd 3.382e-3
rk233 n19__vdd n20__vdd 75
rk234 n2__net18 n10__net18 45.1191
rk235 n2__out0 n1__out0 21.0106
rk236 n1__out0 n3__out0 75.1317
rk237 n6__i33__i26__net1 n4__i33__i26__net1 6.34e-3
rk238 n7__i33__i26__net1 n8__i33__i26__net1 6.314e-3
rk239 n6__i33__i26__net1 n8__i33__i26__net1 26.25e-3
rk240 n2__i33__i26__net1 n7__i33__i26__net1 45
rk241 n267__clk1pt6g n323__clk1pt6g 3.014e-3
rk243 n3__net23 n48__net23 3.265e-3
rk245 net23 n50__net23 557e-3
rk246 n2__i29__net26 n3__i29__net26 4.773e-3
rk247 i29__net26 n2__i29__net26 75
rk248 n2__net19 n3__net19 13.27e-3
rk249 net19 n2__net19 31
rk251 n6__i28__i69__net2 n8__i28__i69__net2 28.64e-3
rk252 n7__i28__i69__net2 n8__i28__i69__net2 15.5
rk253 n3__i28__i69__net3 n4__i28__i69__net3 38.041
rk254 n13__clk100m_b n59__clk100m_b 2.658e-3
rk256 n274__clk1pt6g n327__clk1pt6g 677e-3
rk257 n4__net22 n40__net22 675.3e-3
rk258 n63__clk100m_b n11__clk100m_b 19.54e-3
rk259 n22__vdd n23__vdd 2.601e-3
rk260 n25__vdd n26__vdd 2.601e-3
rk261 n22__vdd n26__vdd 15.28e-3
rk262 n24__vdd n25__vdd 31
rk263 n160__clk100m n12__clk100m 2.493e-3
rk264 net29 n32__net29 3.674e-3
rk265 n268__clk1pt6g n330__clk1pt6g 3.265e-3
rk266 n13__net14 n15__net14 2.601e-3
rk267 n16__net14 n17__net14 2.601e-3
rk268 n13__net14 n17__net14 15.28e-3
rk269 n14__net14 n15__net14 31
rk270 n54__rst n55__rst 6.895e-3
rk271 n53__rst n54__rst 75
rk272 n36__net16 n38__net16 6.895e-3
rk273 n37__net16 n38__net16 75
rk274 n13__rst n57__rst 3.265e-3
rk275 n270__clk1pt6g n332__clk1pt6g 500e-3
rk276 n3__i29__i130__x n5__i29__i130__x 85.19e-3
rk277 n5__i29__i130__x n6__i29__i130__x 75.2385
rk278 n5__i29__i130__x n7__i29__i130__x 31.3419
rk279 n163__clk100m n15__clk100m 504.5e-3
rk280 n9__i33__i26__net1 n10__i33__i26__net1 75.3656
rk281 n10__i33__i26__net1 n11__i33__i26__net1 31.0029
rk282 n5__net19 n6__net19 852.8e-3
rk283 n6__net19 n7__net19 75.1291
rk284 n6__net19 n8__net19 31.2567
rk285 n3__i33__i26__x n5__i33__i26__x 78.72e-3
rk286 n5__i33__i26__x n6__i33__i26__x 75.2443
rk287 n5__i33__i26__x n7__i33__i26__x 31.3568
rk288 n6__i28__i69__net3 n5__i28__i69__net3 37.5571
rk289 n5__i29__net26 n6__i29__net26 2.601e-3
rk290 n7__i29__net26 n8__i29__net26 2.601e-3
rk291 n6__i29__net26 n7__i29__net26 15.28e-3
rk292 n4__i29__net26 n5__i29__net26 31
rk293 n4__i40__i57__x n5__i40__i57__x 20.9555
rk294 n5__i40__i57__x n2__i40__i57__x 45.1172
rk295 n5__i40__i57__x n6__i40__i57__x 75.2238
rk297 i28__i69__net2 n13__i28__i69__net2 42.96e-3
rk298 n12__i28__i69__net2 n13__i28__i69__net2 15.5
rk299 n12__net19 n13__net19 6.895e-3
rk300 n11__net19 n12__net19 75
rk301 n279__clk1pt6g n337__clk1pt6g 4.773e-3
rk302 n281__clk1pt6g n336__clk1pt6g 3.265e-3
rk304 n56__net23 n5__net23 3.265e-3
rk306 n39__rst_b n9__rst_b 9.796e-3
rk307 n16__clk100m n168__clk100m 4.773e-3
rk308 n18__clk100m n169__clk100m 2.658e-3
rk310 n70__clk100m_b n18__clk100m_b 3.265e-3
rk311 n341__clk1pt6g n278__clk1pt6g 3.674e-3
rk312 n37__net29 n4__net29 3.265e-3
rk313 n5__i28__i69__x n9__i28__i69__x 45.3066
rk314 n9__i28__i69__x n10__i28__i69__x 37.7383
rk315 n9__i28__i69__x n11__i28__i69__x 15.8225
rk316 n9__i29__net26 n12__i29__net26 48.49e-3
rk317 n12__i29__net26 n13__i29__net26 75.5577
rk318 n11__i29__net26 n12__i29__net26 31
rk319 n64__rst n66__rst 13.53e-3
rk320 n66__rst n67__rst 349.6e-3
rk322 n65__rst n66__rst 31
rk326 n3__i28__i69__net4 n2__i28__i69__net4 15.5
rk327 i28__i69__net5 n2__i28__i69__net5 38.0391
rk328 n13__net15 n14__net15 31.2956
rk329 n14__net15 n15__net15 75.2544
rk330 n19__net14 n18__net14 672.8e-3
rk331 n18__net14 n22__net14 75.0029
rk332 n16__net15 n18__net15 13.27e-3
rk333 n17__net15 n18__net15 31
rk334 n30__vdd n31__vdd 3.382e-3
rk335 n29__vdd n30__vdd 75
rk336 n2__i29__net27 n4__i29__net27 508.6e-3
rk337 n4__i29__net27 n5__i29__net27 31.2567
rk338 n4__i29__net27 n6__i29__net27 75.1255
rk339 n6__out1 n7__out1 20.9587
rk340 n7__out1 n1__out1 91.08e-3
rk341 n7__out1 n5__out1 60.67e-3
rk342 n5__out1 n8__out1 75.1321
rk343 n6__i33__i29__net1 n4__i33__i29__net1 6.34e-3
rk344 n7__i33__i29__net1 n8__i33__i29__net1 6.314e-3
rk345 n6__i33__i29__net1 n8__i33__i29__net1 26.25e-3
rk346 n2__i33__i29__net1 n7__i33__i29__net1 45
rk347 n289__clk1pt6g n347__clk1pt6g 3.014e-3
rk349 n8__net23 n59__net23 3.265e-3
rk354 n8__i28__i69__net4 n7__i28__i69__net4 15.5
rk355 n3__i28__i69__net5 n4__i28__i69__net5 38.041
rk356 n6__net23 n61__net23 557e-3
rk357 n10__net22 n41__net22 177e-3
rk358 n295__clk1pt6g n346__clk1pt6g 175.3e-3
rk359 n2__i29__net19 n3__i29__net19 4.773e-3
rk360 i29__net19 n2__i29__net19 75
rk361 n2__net38 n3__net38 13.27e-3
rk362 net38 n2__net38 31
rk363 n21__clk100m_b n73__clk100m_b 2.658e-3
rk365 n77__clk100m_b n19__clk100m_b 19.54e-3
rk366 n32__vdd n33__vdd 2.601e-3
rk367 n35__vdd n36__vdd 2.601e-3
rk368 n32__vdd n36__vdd 15.28e-3
rk369 n34__vdd n35__vdd 31
rk370 n175__clk100m n20__clk100m 2.493e-3
rk371 n5__net29 n41__net29 3.674e-3
rk372 n290__clk1pt6g n353__clk1pt6g 3.265e-3
rk373 net13 n3__net13 2.601e-3
rk374 n4__net13 n5__net13 2.601e-3
rk375 net13 n5__net13 15.28e-3
rk376 n2__net13 n3__net13 31
rk377 n70__rst n71__rst 6.895e-3
rk378 n69__rst n70__rst 75
rk379 n23__net15 n25__net15 6.895e-3
rk380 n24__net15 n25__net15 75
rk381 n6__net22 n42__net22 500e-3
rk382 n18__rst n73__rst 3.265e-3
rk383 n3__i29__i131__x n5__i29__i131__x 85.19e-3
rk384 n5__i29__i131__x n6__i29__i131__x 75.2385
rk385 n5__i29__i131__x n7__i29__i131__x 31.3419
rk386 n178__clk100m n23__clk100m 504.5e-3
rk387 n9__i33__i29__net1 n10__i33__i29__net1 75.3656
rk388 n10__i33__i29__net1 n11__i33__i29__net1 31.0029
rk389 n6__i28__i69__net5 n5__i28__i69__net5 37.5429
rk393 n14__i28__i69__net4 i28__i69__net4 15.5
rk394 n5__net38 n6__net38 852.8e-3
rk395 n6__net38 n7__net38 75.1291
rk396 n6__net38 n8__net38 31.2567
rk397 n3__i33__i29__x n5__i33__i29__x 78.72e-3
rk398 n5__i33__i29__x n6__i33__i29__x 75.2443
rk399 n5__i33__i29__x n7__i33__i29__x 31.3568
rk400 n5__i29__net19 n6__i29__net19 2.601e-3
rk401 n7__i29__net19 n8__i29__net19 2.601e-3
rk402 n6__i29__net19 n7__i29__net19 15.28e-3
rk403 n4__i29__net19 n5__i29__net19 31
rk404 n4__i40__i56__x n5__i40__i56__x 20.9555
rk405 n5__i40__i56__x n2__i40__i56__x 45.1172
rk406 n5__i40__i56__x n6__i40__i56__x 75.2238
rk407 n12__net38 n13__net38 6.895e-3
rk408 n11__net38 n12__net38 75
rk409 n299__clk1pt6g n357__clk1pt6g 4.773e-3
rk410 n301__clk1pt6g n356__clk1pt6g 3.265e-3
rk412 n65__net23 n10__net23 3.265e-3
rk414 n52__rst_b n12__rst_b 9.796e-3
rk415 n49__rst_b n52__rst_b 500e-3
rk416 n7__i28__net9 n31__i28__net9 45.3157
rk417 n31__i28__net9 n32__i28__net9 37.7383
rk418 n31__i28__net9 n33__i28__net9 15.8225
rk419 n24__clk100m n185__clk100m 4.773e-3
rk420 n26__clk100m n183__clk100m 2.658e-3
rk422 n84__clk100m_b n26__clk100m_b 3.265e-3
rk423 n359__clk1pt6g n298__clk1pt6g 3.674e-3
rk424 n44__net29 n8__net29 3.265e-3
rk425 n9__i29__net19 n12__i29__net19 48.49e-3
rk426 n12__i29__net19 n13__i29__net19 75.5577
rk427 n11__i29__net19 n12__i29__net19 31
rk428 n80__rst n82__rst 13.53e-3
rk429 n82__rst n83__rst 349.6e-3
rk431 n81__rst n82__rst 31
rk432 n25__net14 n26__net14 31.2956
rk433 n26__net14 n27__net14 75.2544
rk434 n12__i28__net1 n13__i28__net1 529.8e-3
rk435 n13__i28__net1 n14__i28__net1 37.6788
rk436 n13__i28__net1 n15__i28__net1 15.7825
rk437 n7__net13 n6__net13 672.8e-3
rk438 n6__net13 n8__net13 75.0029
rk439 i28__net9 n34__i28__net9 500e-3
rk440 n28__net14 n30__net14 13.27e-3
rk441 n29__net14 n30__net14 31
rk442 n40__vdd n41__vdd 3.382e-3
rk443 n39__vdd n40__vdd 75
rk444 n2__i29__net20 n4__i29__net20 508.6e-3
rk445 n4__i29__net20 n5__i29__net20 31.2567
rk446 n4__i29__net20 n6__i29__net20 75.1255
rk447 n6__out2 n7__out2 20.9587
rk448 n7__out2 n1__out2 91.08e-3
rk449 n7__out2 n5__out2 60.67e-3
rk450 n5__out2 n8__out2 75.1321
rk451 n6__i33__i24__net1 n4__i33__i24__net1 6.34e-3
rk452 n7__i33__i24__net1 n8__i33__i24__net1 6.314e-3
rk453 n6__i33__i24__net1 n8__i33__i24__net1 26.25e-3
rk454 n2__i33__i24__net1 n7__i33__i24__net1 45
rk455 n306__clk1pt6g n366__clk1pt6g 3.014e-3
rk457 n13__net23 n68__net23 3.265e-3
rk459 n11__net23 n70__net23 557e-3
rk460 n2__i29__net9 n3__i29__net9 4.773e-3
rk461 i29__net9 n2__i29__net9 75
rk462 n2__net39 n3__net39 13.27e-3
rk463 net39 n2__net39 31
rk464 n35__clk100m_b n87__clk100m_b 2.658e-3
rk466 n91__clk100m_b n33__clk100m_b 19.54e-3
rk467 n42__vdd n43__vdd 2.601e-3
rk468 n45__vdd n46__vdd 2.601e-3
rk469 n42__vdd n46__vdd 15.28e-3
rk470 n44__vdd n45__vdd 31
rk471 n190__clk100m n29__clk100m 2.493e-3
rk472 n9__net29 n50__net29 3.674e-3
rk473 n307__clk1pt6g n372__clk1pt6g 3.265e-3
rk474 net12 n3__net12 2.601e-3
rk475 n4__net12 n5__net12 2.601e-3
rk476 net12 n5__net12 15.28e-3
rk477 n2__net12 n3__net12 31
rk478 n86__rst n87__rst 6.895e-3
rk479 n85__rst n86__rst 75
rk480 n35__net14 n37__net14 6.895e-3
rk481 n36__net14 n37__net14 75
rk482 n28__rst n89__rst 3.265e-3
rk483 n13__i28__net20 n14__i28__net20 538.6e-3
rk484 n14__i28__net20 n15__i28__net20 37.682
rk485 n14__i28__net20 n16__i28__net20 15.7792
rk486 n3__i29__i132__x n5__i29__i132__x 85.19e-3
rk487 n5__i29__i132__x n6__i29__i132__x 75.2385
rk488 n5__i29__i132__x n7__i29__i132__x 31.3419
rk489 n193__clk100m n32__clk100m 504.5e-3
rk490 n98__clk100m_b n99__clk100m_b 8.2204
rk491 n99__clk100m_b n100__clk100m_b 263.7e-3
rk492 n100__clk100m_b n101__clk100m_b 283.1e-3
rk493 n101__clk100m_b n102__clk100m_b 283.1e-3
rk494 n102__clk100m_b n103__clk100m_b 283.1e-3
rk495 n103__clk100m_b n104__clk100m_b 283.1e-3
rk496 n104__clk100m_b n105__clk100m_b 283.1e-3
rk497 n105__clk100m_b n106__clk100m_b 283.1e-3
rk498 n106__clk100m_b n56__clk100m_b 468.4e-3
rk499 n99__clk100m_b n107__clk100m_b 19.0261
rk500 n100__clk100m_b n108__clk100m_b 19.0195
rk501 n100__clk100m_b n109__clk100m_b 8.2139
rk502 n101__clk100m_b n110__clk100m_b 19.0195
rk503 n101__clk100m_b n111__clk100m_b 8.2139
rk504 n102__clk100m_b n112__clk100m_b 19.0195
rk505 n102__clk100m_b n113__clk100m_b 8.2139
rk506 n103__clk100m_b n114__clk100m_b 19.0195
rk507 n103__clk100m_b n115__clk100m_b 8.2139
rk508 n104__clk100m_b n116__clk100m_b 19.0195
rk509 n104__clk100m_b n117__clk100m_b 8.2139
rk510 n105__clk100m_b n118__clk100m_b 19.0195
rk511 n105__clk100m_b n119__clk100m_b 8.2139
rk512 n106__clk100m_b n120__clk100m_b 19.0195
rk513 n106__clk100m_b n121__clk100m_b 8.2139
rk514 n9__i33__i24__net1 n10__i33__i24__net1 75.3656
rk515 n10__i33__i24__net1 n11__i33__i24__net1 31.0029
rk516 n5__net39 n6__net39 852.8e-3
rk517 n6__net39 n7__net39 75.1291
rk518 n6__net39 n8__net39 31.2567
rk519 n3__i33__i24__x n5__i33__i24__x 78.72e-3
rk520 n5__i33__i24__x n6__i33__i24__x 75.2443
rk521 n5__i33__i24__x n7__i33__i24__x 31.3568
rk522 n5__i29__net9 n6__i29__net9 2.601e-3
rk523 n7__i29__net9 n8__i29__net9 2.601e-3
rk524 n6__i29__net9 n7__i29__net9 15.28e-3
rk525 n4__i29__net9 n5__i29__net9 31
rk526 n4__i40__i55__x n5__i40__i55__x 20.9555
rk527 n5__i40__i55__x n2__i40__i55__x 45.1172
rk528 n5__i40__i55__x n6__i40__i55__x 75.2238
rk529 n12__net39 n13__net39 6.895e-3
rk530 n11__net39 n12__net39 75
rk531 n311__clk1pt6g n376__clk1pt6g 4.773e-3
rk532 n313__clk1pt6g n375__clk1pt6g 3.265e-3
rk534 n74__net23 n15__net23 3.265e-3
rk536 n59__rst_b n17__rst_b 9.796e-3
rk537 n144__clk100m n198__clk100m 4.773e-3
rk538 n146__clk100m n199__clk100m 2.658e-3
rk540 n122__clk100m_b n41__clk100m_b 3.265e-3
rk541 n378__clk1pt6g n310__clk1pt6g 3.674e-3
rk542 n53__net29 n12__net29 3.265e-3
rk543 n5__i28__net15 n9__i28__net15 45.0612
rk544 n9__i29__net9 n12__i29__net9 48.49e-3
rk545 n12__i29__net9 n13__i29__net9 75.5577
rk546 n11__i29__net9 n12__i29__net9 31
rk547 n96__rst n98__rst 13.53e-3
rk548 n98__rst n99__rst 349.6e-3
rk550 n97__rst n98__rst 31
rk551 n13__net13 n14__net13 31.2956
rk552 n14__net13 n15__net13 75.2544
rk553 n7__net12 n6__net12 672.8e-3
rk554 n6__net12 n8__net12 75.0029
rk555 i28__i70__net3 n2__i28__i70__net3 38.0375
rk557 n2__i28__i70__net2 n4__i28__i70__net2 42.96e-3
rk558 n3__i28__i70__net2 n4__i28__i70__net2 15.5
rk559 n16__net13 n18__net13 13.27e-3
rk560 n17__net13 n18__net13 31
rk561 n50__vdd n51__vdd 3.382e-3
rk562 n49__vdd n50__vdd 75
rk563 n2__i29__net10 n4__i29__net10 508.6e-3
rk564 n4__i29__net10 n5__i29__net10 31.2567
rk565 n4__i29__net10 n6__i29__net10 75.1255
rk566 n6__out3 n7__out3 20.9587
rk567 n7__out3 n1__out3 91.08e-3
rk568 n7__out3 n5__out3 60.67e-3
rk569 n5__out3 n8__out3 75.1321
rk570 n6__i33__i25__net1 n4__i33__i25__net1 6.34e-3
rk571 n7__i33__i25__net1 n8__i33__i25__net1 6.314e-3
rk572 n6__i33__i25__net1 n8__i33__i25__net1 26.25e-3
rk573 n2__i33__i25__net1 n7__i33__i25__net1 45
rk574 n315__clk1pt6g n385__clk1pt6g 3.014e-3
rk576 n18__net23 n77__net23 3.265e-3
rk578 n16__net23 n79__net23 557e-3
rk580 n6__i28__i70__net2 n8__i28__i70__net2 28.64e-3
rk581 n7__i28__i70__net2 n8__i28__i70__net2 15.5
rk582 n3__i28__i70__net3 n4__i28__i70__net3 38.041
rk583 n2__i29__net16 n3__i29__net16 4.773e-3
rk584 i29__net16 n2__i29__net16 75
rk585 n2__net40 n3__net40 13.27e-3
rk586 net40 n2__net40 31
rk587 n49__clk100m_b n125__clk100m_b 2.658e-3
rk589 n5__i28__net20 n17__i28__net20 677e-3
rk590 n22__i28__net9 n36__i28__net9 675.3e-3
rk591 n129__clk100m_b n47__clk100m_b 19.54e-3
rk592 n52__vdd n53__vdd 2.601e-3
rk593 n55__vdd n56__vdd 2.601e-3
rk594 n52__vdd n56__vdd 15.28e-3
rk595 n54__vdd n55__vdd 31
rk596 n207__clk100m n149__clk100m 2.493e-3
rk597 n13__net29 n59__net29 3.674e-3
rk598 n316__clk1pt6g n391__clk1pt6g 3.265e-3
rk600 net11 n3__net11 2.601e-3
rk601 n4__net11 n5__net11 2.601e-3
rk602 net11 n5__net11 15.28e-3
rk603 n2__net11 n3__net11 31
rk604 n102__rst n103__rst 6.895e-3
rk605 n101__rst n102__rst 75
rk606 n23__net13 n25__net13 6.895e-3
rk607 n24__net13 n25__net13 75
rk608 n44__rst n105__rst 3.265e-3
rk609 n3__i29__i133__x n5__i29__i133__x 85.19e-3
rk610 n5__i29__i133__x n6__i29__i133__x 75.2385
rk611 n5__i29__i133__x n7__i29__i133__x 31.3419
rk612 n210__clk100m n152__clk100m 504.5e-3
rk613 n9__i33__i25__net1 n10__i33__i25__net1 75.3656
rk614 n10__i33__i25__net1 n11__i33__i25__net1 31.0029
rk615 n5__net40 n6__net40 852.8e-3
rk616 n6__net40 n7__net40 75.1291
rk617 n6__net40 n8__net40 31.2567
rk618 n3__i33__i25__x n5__i33__i25__x 78.72e-3
rk619 n5__i33__i25__x n6__i33__i25__x 75.2443
rk620 n5__i33__i25__x n7__i33__i25__x 31.3568
rk621 n5__i28__i70__net3 n6__i28__i70__net3 38.0571
rk623 i28__i70__net2 n12__i28__i70__net2 42.96e-3
rk624 n11__i28__i70__net2 n12__i28__i70__net2 15.5
rk625 n5__i29__net16 n6__i29__net16 2.601e-3
rk626 n7__i29__net16 n8__i29__net16 2.601e-3
rk627 n6__i29__net16 n7__i29__net16 15.28e-3
rk628 n4__i29__net16 n5__i29__net16 31
rk629 n4__i40__i54__x n5__i40__i54__x 20.9555
rk630 n5__i40__i54__x n2__i40__i54__x 45.1172
rk631 n5__i40__i54__x n6__i40__i54__x 75.2238
rk632 n12__net40 n13__net40 6.895e-3
rk633 n11__net40 n12__net40 75
rk634 n320__clk1pt6g n395__clk1pt6g 4.773e-3
rk635 n322__clk1pt6g n394__clk1pt6g 3.265e-3
rk637 n83__net23 n47__net23 3.265e-3
rk639 n69__rst_b n27__rst_b 9.796e-3
rk640 n157__clk100m n215__clk100m 4.773e-3
rk641 n159__clk100m n216__clk100m 2.658e-3
rk643 n136__clk100m_b n58__clk100m_b 3.265e-3
rk644 n397__clk1pt6g n319__clk1pt6g 3.674e-3
rk645 n62__net29 n29__net29 3.265e-3
rk646 n5__i28__i70__x n9__i28__i70__x 45.3066
rk647 n9__i28__i70__x n10__i28__i70__x 37.7383
rk648 n9__i28__i70__x n11__i28__i70__x 15.8225
rk649 n9__i29__net16 n12__i29__net16 48.49e-3
rk650 n12__i29__net16 n13__i29__net16 75.5577
rk651 n11__i29__net16 n12__i29__net16 31
rk652 n112__rst n114__rst 13.53e-3
rk653 n114__rst n115__rst 350.6e-3
rk655 n113__rst n114__rst 31
rk659 n3__i28__i70__net4 n2__i28__i70__net4 15.5
rk660 i28__i70__net5 n2__i28__i70__net5 38.0391
rk661 n13__net12 n14__net12 31.2956
rk662 n14__net12 n15__net12 75.2544
rk663 n7__net11 n6__net11 672.8e-3
rk664 n6__net11 n8__net11 75.0029
rk665 n16__net12 n18__net12 13.27e-3
rk666 n17__net12 n18__net12 31
rk667 n60__vdd n61__vdd 3.382e-3
rk668 n59__vdd n60__vdd 75
rk669 n2__i29__net17 n4__i29__net17 508.6e-3
rk670 n4__i29__net17 n5__i29__net17 31.2567
rk671 n4__i29__net17 n6__i29__net17 75.1255
rk672 n6__out4 n7__out4 20.9587
rk673 n7__out4 n1__out4 91.08e-3
rk674 n7__out4 n5__out4 60.67e-3
rk675 n5__out4 n8__out4 75.1321
rk676 n6__i33__i23__net1 n4__i33__i23__net1 6.34e-3
rk677 n7__i33__i23__net1 n8__i33__i23__net1 6.314e-3
rk678 n6__i33__i23__net1 n8__i33__i23__net1 26.25e-3
rk679 n2__i33__i23__net1 n7__i33__i23__net1 45
rk680 n326__clk1pt6g n404__clk1pt6g 3.014e-3
rk682 n55__net23 n86__net23 3.265e-3
rk687 n8__i28__i70__net4 n7__i28__i70__net4 15.5
rk688 n3__i28__i70__net5 n4__i28__i70__net5 38.041
rk689 n28__i28__net9 n37__i28__net9 177e-3
rk690 n11__i28__net20 n19__i28__net20 175.3e-3
rk691 n53__net23 n88__net23 557e-3
rk692 n2__i29__net29 n3__i29__net29 4.773e-3
rk693 i29__net29 n2__i29__net29 75
rk694 n2__net41 n3__net41 13.27e-3
rk695 net41 n2__net41 31
rk696 n66__clk100m_b n139__clk100m_b 2.658e-3
rk698 n24__i28__net9 n38__i28__net9 500e-3
rk699 n143__clk100m_b n64__clk100m_b 19.54e-3
rk700 n62__vdd n63__vdd 2.601e-3
rk701 n65__vdd n66__vdd 2.601e-3
rk702 n62__vdd n66__vdd 15.28e-3
rk703 n64__vdd n65__vdd 31
rk704 n222__clk100m n162__clk100m 2.493e-3
rk705 n30__net29 n68__net29 3.674e-3
rk706 n328__clk1pt6g n410__clk1pt6g 3.265e-3
rk707 net10 n3__net10 2.601e-3
rk708 n4__net10 n5__net10 2.601e-3
rk709 net10 n5__net10 15.28e-3
rk710 n2__net10 n3__net10 31
rk711 n118__rst n119__rst 6.895e-3
rk712 n117__rst n118__rst 75
rk713 n23__net12 n25__net12 6.895e-3
rk714 n24__net12 n25__net12 75
rk715 n60__rst n121__rst 3.265e-3
rk716 n3__i29__i134__x n5__i29__i134__x 85.19e-3
rk717 n5__i29__i134__x n6__i29__i134__x 75.2385
rk718 n5__i29__i134__x n7__i29__i134__x 31.3419
rk719 n225__clk100m n167__clk100m 504.5e-3
rk720 n9__i33__i23__net1 n10__i33__i23__net1 75.3656
rk721 n10__i33__i23__net1 n11__i33__i23__net1 31.0029
rk722 n6__i28__i70__net5 n5__i28__i70__net5 37.5429
rk726 n14__i28__i70__net4 i28__i70__net4 15.5
rk727 n5__net41 n6__net41 852.8e-3
rk728 n6__net41 n7__net41 75.1291
rk729 n6__net41 n8__net41 31.2567
rk730 n3__i33__i23__x n5__i33__i23__x 78.72e-3
rk731 n5__i33__i23__x n6__i33__i23__x 75.2443
rk732 n5__i33__i23__x n7__i33__i23__x 31.3568
rk733 n5__i29__net29 n6__i29__net29 2.601e-3
rk734 n7__i29__net29 n8__i29__net29 2.601e-3
rk735 n6__i29__net29 n7__i29__net29 15.28e-3
rk736 n4__i29__net29 n5__i29__net29 31
rk737 n4__i40__i53__x n5__i40__i53__x 20.9555
rk738 n5__i40__i53__x n2__i40__i53__x 45.1172
rk739 n5__i40__i53__x n6__i40__i53__x 75.2238
rk740 n12__net41 n13__net41 6.895e-3
rk741 n11__net41 n12__net41 75
rk742 n343__clk1pt6g n414__clk1pt6g 4.773e-3
rk743 n345__clk1pt6g n413__clk1pt6g 3.265e-3
rk745 n92__net23 n58__net23 3.265e-3
rk746 n7__i28__net3 n31__i28__net3 45.3157
rk747 n31__i28__net3 n32__i28__net3 37.7383
rk748 n31__i28__net3 n33__i28__net3 15.8225
rk750 n79__rst_b n37__rst_b 9.796e-3
rk751 n172__clk100m n230__clk100m 4.773e-3
rk752 n174__clk100m n231__clk100m 2.658e-3
rk754 n150__clk100m_b n72__clk100m_b 3.265e-3
rk755 n416__clk1pt6g n340__clk1pt6g 3.674e-3
rk756 n71__net29 n36__net29 3.265e-3
rk757 n9__i29__net29 n12__i29__net29 48.49e-3
rk758 n12__i29__net29 n13__i29__net29 75.5577
rk759 n11__i29__net29 n12__i29__net29 31
rk760 n128__rst n130__rst 13.53e-3
rk761 n130__rst n131__rst 349.6e-3
rk763 n129__rst n130__rst 31
rk764 n13__net11 n14__net11 31.2956
rk765 n14__net11 n15__net11 75.2544
rk766 n11__i28__net15 n12__i28__net15 529.8e-3
rk767 n12__i28__net15 n13__i28__net15 37.6788
rk768 n12__i28__net15 n14__i28__net15 15.7825
rk769 n7__net10 n6__net10 672.8e-3
rk770 n6__net10 n8__net10 75.0029
rk771 i28__net3 n34__i28__net3 500e-3
rk772 n16__net11 n18__net11 13.27e-3
rk773 n17__net11 n18__net11 31
rk774 n70__vdd n71__vdd 3.382e-3
rk775 n69__vdd n70__vdd 75
rk776 n2__i29__net30 n4__i29__net30 508.6e-3
rk777 n4__i29__net30 n5__i29__net30 31.2567
rk778 n4__i29__net30 n6__i29__net30 75.1255
rk779 n6__out5 n7__out5 20.9587
rk780 n7__out5 n1__out5 91.08e-3
rk781 n7__out5 n5__out5 60.67e-3
rk782 n5__out5 n8__out5 75.1321
rk783 n6__i33__i30__net1 n4__i33__i30__net1 6.34e-3
rk784 n7__i33__i30__net1 n8__i33__i30__net1 6.314e-3
rk785 n6__i33__i30__net1 n8__i33__i30__net1 26.25e-3
rk786 n2__i33__i30__net1 n7__i33__i30__net1 45
rk787 n350__clk1pt6g n423__clk1pt6g 3.014e-3
rk789 n64__net23 n95__net23 3.265e-3
rk791 n237__clk100m n238__clk100m 8.2204
rk792 n238__clk100m n239__clk100m 263.7e-3
rk793 n239__clk100m n240__clk100m 283.1e-3
rk794 n240__clk100m n241__clk100m 283.1e-3
rk795 n241__clk100m n242__clk100m 283.1e-3
rk796 n242__clk100m n243__clk100m 283.1e-3
rk797 n243__clk100m n244__clk100m 283.1e-3
rk798 n244__clk100m n245__clk100m 283.1e-3
rk799 n245__clk100m n203__clk100m 212.5e-3
rk800 n203__clk100m n37__clk100m 90.32e-3
rk801 n238__clk100m n246__clk100m 19.0261
rk802 n239__clk100m n247__clk100m 19.0195
rk803 n239__clk100m n248__clk100m 8.2139
rk804 n240__clk100m n249__clk100m 19.0195
rk805 n240__clk100m n250__clk100m 8.2139
rk806 n241__clk100m n251__clk100m 19.0195
rk807 n241__clk100m n252__clk100m 8.2139
rk808 n242__clk100m n253__clk100m 19.0195
rk809 n242__clk100m n254__clk100m 8.2139
rk810 n243__clk100m n255__clk100m 19.0195
rk811 n243__clk100m n256__clk100m 8.2139
rk812 n244__clk100m n257__clk100m 19.0195
rk813 n244__clk100m n258__clk100m 8.2139
rk814 n245__clk100m n259__clk100m 19.0195
rk815 n245__clk100m n260__clk100m 8.2139
rk816 n62__net23 n97__net23 557e-3
rk817 n2__i29__net21 n3__i29__net21 4.773e-3
rk818 i29__net21 n2__i29__net21 75
rk819 n2__net42 n3__net42 13.27e-3
rk820 net42 n2__net42 31
rk821 n80__clk100m_b n153__clk100m_b 2.658e-3
rk823 n157__clk100m_b n78__clk100m_b 19.54e-3
rk824 n72__vdd n73__vdd 2.601e-3
rk825 n75__vdd n76__vdd 2.601e-3
rk826 n72__vdd n76__vdd 15.28e-3
rk827 n74__vdd n75__vdd 31
rk828 n261__clk100m n177__clk100m 2.493e-3
rk829 n39__net29 n77__net29 3.674e-3
rk830 n351__clk1pt6g n429__clk1pt6g 3.265e-3
rk831 net9 n3__net9 2.601e-3
rk832 n4__net9 n5__net9 2.601e-3
rk833 net9 n5__net9 15.28e-3
rk834 n2__net9 n3__net9 31
rk835 n134__rst n135__rst 6.895e-3
rk836 n133__rst n134__rst 75
rk837 n23__net11 n25__net11 6.895e-3
rk838 n24__net11 n25__net11 75
rk839 n76__rst n137__rst 3.265e-3
rk840 n13__i28__net23 n14__i28__net23 538.6e-3
rk841 n14__i28__net23 n15__i28__net23 37.682
rk842 n14__i28__net23 n16__i28__net23 15.7792
rk843 n3__i29__i135__x n5__i29__i135__x 85.19e-3
rk844 n5__i29__i135__x n6__i29__i135__x 75.2385
rk845 n5__i29__i135__x n7__i29__i135__x 31.3419
rk846 n264__clk100m n182__clk100m 504.5e-3
rk847 n9__i33__i30__net1 n10__i33__i30__net1 75.3656
rk848 n10__i33__i30__net1 n11__i33__i30__net1 31.0029
rk849 n5__net42 n6__net42 852.8e-3
rk850 n6__net42 n7__net42 75.1291
rk851 n6__net42 n8__net42 31.2567
rk852 n3__i33__i30__x n5__i33__i30__x 78.72e-3
rk853 n5__i33__i30__x n6__i33__i30__x 75.2443
rk854 n5__i33__i30__x n7__i33__i30__x 31.3568
rk855 n5__i29__net21 n6__i29__net21 2.601e-3
rk856 n7__i29__net21 n8__i29__net21 2.601e-3
rk857 n6__i29__net21 n7__i29__net21 15.28e-3
rk858 n4__i29__net21 n5__i29__net21 31
rk859 n4__i40__i52__x n5__i40__i52__x 20.9555
rk860 n5__i40__i52__x n2__i40__i52__x 45.1172
rk861 n5__i40__i52__x n6__i40__i52__x 75.2238
rk862 n12__net42 n13__net42 6.895e-3
rk863 n11__net42 n12__net42 75
rk864 n363__clk1pt6g n431__clk1pt6g 4.773e-3
rk865 n365__clk1pt6g n432__clk1pt6g 3.265e-3
rk867 n101__net23 n67__net23 3.265e-3
rk869 n89__rst_b n47__rst_b 9.796e-3
rk870 n187__clk100m n269__clk100m 4.773e-3
rk871 n189__clk100m n270__clk100m 2.658e-3
rk873 n164__clk100m_b n86__clk100m_b 3.265e-3
rk874 n435__clk1pt6g n362__clk1pt6g 3.674e-3
rk875 n80__net29 n47__net29 3.265e-3
rk876 n5__i28__net17 n9__i28__net17 45.0612
rk877 n9__i29__net21 n12__i29__net21 48.49e-3
rk878 n12__i29__net21 n13__i29__net21 75.5577
rk879 n11__i29__net21 n12__i29__net21 31
rk880 n144__rst n146__rst 13.53e-3
rk881 n146__rst n147__rst 349.6e-3
rk883 n145__rst n146__rst 31
rk884 n13__net10 n14__net10 31.2956
rk885 n14__net10 n15__net10 75.2544
rk886 i28__i71__net3 n2__i28__i71__net3 38.0375
rk888 n2__i28__i71__net2 n4__i28__i71__net2 42.96e-3
rk889 n3__i28__i71__net2 n4__i28__i71__net2 15.5
rk890 n7__net9 n6__net9 672.8e-3
rk891 n6__net9 n8__net9 75.0029
rk892 n16__net10 n18__net10 13.27e-3
rk893 n17__net10 n18__net10 31
rk894 n80__vdd n81__vdd 3.382e-3
rk895 n79__vdd n80__vdd 75
rk896 n2__i29__net22 n4__i29__net22 508.6e-3
rk897 n4__i29__net22 n5__i29__net22 31.2567
rk898 n4__i29__net22 n6__i29__net22 75.1255
rk899 n6__out6 n7__out6 20.9587
rk900 n7__out6 n1__out6 91.08e-3
rk901 n7__out6 n5__out6 60.67e-3
rk902 n5__out6 n8__out6 75.1321
rk903 n6__i33__i20__net1 n4__i33__i20__net1 6.34e-3
rk904 n7__i33__i20__net1 n8__i33__i20__net1 6.314e-3
rk905 n6__i33__i20__net1 n8__i33__i20__net1 26.25e-3
rk906 n2__i33__i20__net1 n7__i33__i20__net1 45
rk907 n369__clk1pt6g n442__clk1pt6g 3.014e-3
rk909 n73__net23 n104__net23 3.265e-3
rk912 n6__i28__i71__net2 n8__i28__i71__net2 28.64e-3
rk913 n7__i28__i71__net2 n8__i28__i71__net2 15.5
rk914 n3__i28__i71__net3 n4__i28__i71__net3 38.041
rk915 n71__net23 n106__net23 557e-3
rk916 n2__i29__net14 n3__i29__net14 4.773e-3
rk917 i29__net14 n2__i29__net14 75
rk918 n2__net43 n3__net43 13.27e-3
rk919 net43 n2__net43 31
rk920 n5__i28__net23 n17__i28__net23 677e-3
rk921 n22__i28__net3 n36__i28__net3 675.3e-3
rk922 n94__clk100m_b n167__clk100m_b 2.658e-3
rk924 n171__clk100m_b n92__clk100m_b 19.54e-3
rk925 n82__vdd n83__vdd 2.601e-3
rk926 n85__vdd n86__vdd 2.601e-3
rk927 n82__vdd n86__vdd 15.28e-3
rk928 n84__vdd n85__vdd 31
rk929 n276__clk100m n192__clk100m 2.493e-3
rk931 n48__net29 n86__net29 3.674e-3
rk932 n370__clk1pt6g n448__clk1pt6g 3.265e-3
rk933 net8 n3__net8 2.601e-3
rk934 n4__net8 n5__net8 2.601e-3
rk935 net8 n5__net8 15.28e-3
rk936 n2__net8 n3__net8 31
rk937 n150__rst n151__rst 6.895e-3
rk938 n149__rst n150__rst 75
rk939 n23__net10 n25__net10 6.895e-3
rk940 n24__net10 n25__net10 75
rk941 n92__rst n153__rst 3.265e-3
rk942 n3__i29__i136__x n5__i29__i136__x 85.19e-3
rk943 n5__i29__i136__x n6__i29__i136__x 75.2385
rk944 n5__i29__i136__x n7__i29__i136__x 31.3419
rk945 n279__clk100m n197__clk100m 504.5e-3
rk946 n9__i33__i20__net1 n10__i33__i20__net1 75.3656
rk947 n10__i33__i20__net1 n11__i33__i20__net1 31.0029
rk948 n5__i28__i71__net3 n6__i28__i71__net3 38.0571
rk949 n5__net43 n6__net43 852.8e-3
rk950 n6__net43 n7__net43 75.1291
rk951 n6__net43 n8__net43 31.2567
rk952 n3__i33__i20__x n5__i33__i20__x 78.72e-3
rk953 n5__i33__i20__x n6__i33__i20__x 75.2443
rk954 n5__i33__i20__x n7__i33__i20__x 31.3568
rk956 i28__i71__net2 n12__i28__i71__net2 42.96e-3
rk957 n11__i28__i71__net2 n12__i28__i71__net2 15.5
rk958 n5__i29__net14 n6__i29__net14 2.601e-3
rk959 n7__i29__net14 n8__i29__net14 2.601e-3
rk960 n6__i29__net14 n7__i29__net14 15.28e-3
rk961 n4__i29__net14 n5__i29__net14 31
rk962 n4__i40__i51__x n5__i40__i51__x 20.9555
rk963 n5__i40__i51__x n2__i40__i51__x 45.1172
rk964 n5__i40__i51__x n6__i40__i51__x 75.2238
rk965 n12__net43 n13__net43 6.895e-3
rk966 n11__net43 n12__net43 75
rk967 n108__i28__net14 n109__i28__net14 8.2204
rk968 n109__i28__net14 n110__i28__net14 263.7e-3
rk969 n110__i28__net14 n111__i28__net14 283.1e-3
rk970 n111__i28__net14 n112__i28__net14 283.1e-3
rk971 n112__i28__net14 i28__net14 310e-3
rk972 n109__i28__net14 n113__i28__net14 19.0265
rk973 n110__i28__net14 n114__i28__net14 19.0195
rk974 n110__i28__net14 n115__i28__net14 8.2139
rk975 n111__i28__net14 n116__i28__net14 19.0195
rk976 n111__i28__net14 n117__i28__net14 8.2139
rk977 n112__i28__net14 n118__i28__net14 19.0195
rk978 n112__i28__net14 n119__i28__net14 8.2139
rk979 n382__clk1pt6g n457__clk1pt6g 4.773e-3
rk980 n384__clk1pt6g n456__clk1pt6g 3.265e-3
rk982 n110__net23 n76__net23 3.265e-3
rk984 n99__rst_b n57__rst_b 9.796e-3
rk985 n204__clk100m n284__clk100m 4.773e-3
rk986 n206__clk100m n285__clk100m 2.658e-3
rk988 n178__clk100m_b n124__clk100m_b 3.265e-3
rk989 n459__clk1pt6g n381__clk1pt6g 3.674e-3
rk990 n89__net29 n56__net29 3.265e-3
rk991 n5__i28__i71__x n9__i28__i71__x 45.3066
rk992 n9__i28__i71__x n10__i28__i71__x 37.7383
rk993 n9__i28__i71__x n11__i28__i71__x 15.8225
rk994 n9__i29__net14 n12__i29__net14 48.49e-3
rk995 n12__i29__net14 n13__i29__net14 75.5577
rk996 n11__i29__net14 n12__i29__net14 31
rk997 n160__rst n162__rst 13.53e-3
rk998 n162__rst n163__rst 349.6e-3
rk1000 n161__rst n162__rst 31
rk1004 n3__i28__i71__net4 n2__i28__i71__net4 15.5
rk1005 i28__i71__net5 n2__i28__i71__net5 38.0391
rk1006 n13__net9 n14__net9 31.2956
rk1007 n14__net9 n15__net9 75.2544
rk1008 n7__net8 n6__net8 672.8e-3
rk1009 n6__net8 n8__net8 75.0029
rk1010 n16__net9 n18__net9 13.27e-3
rk1011 n17__net9 n18__net9 31
rk1012 n90__vdd n91__vdd 3.382e-3
rk1013 n89__vdd n90__vdd 75
rk1014 n2__i29__net15 n4__i29__net15 508.6e-3
rk1015 n4__i29__net15 n5__i29__net15 31.2567
rk1016 n4__i29__net15 n6__i29__net15 75.1255
rk1017 n6__out7 n7__out7 20.9587
rk1018 n7__out7 n1__out7 91.08e-3
rk1019 n7__out7 n5__out7 60.67e-3
rk1020 n5__out7 n8__out7 75.1321
rk1021 n6__i33__i21__net1 n4__i33__i21__net1 6.34e-3
rk1022 n7__i33__i21__net1 n8__i33__i21__net1 6.314e-3
rk1023 n6__i33__i21__net1 n8__i33__i21__net1 26.25e-3
rk1024 n2__i33__i21__net1 n7__i33__i21__net1 45
rk1025 n52__i28__net10 n53__i28__net10 8.2237
rk1026 n53__i28__net10 i28__net10 305e-3
rk1027 n53__i28__net10 n54__i28__net10 19.0229
rk1028 n388__clk1pt6g n466__clk1pt6g 3.014e-3
rk1030 n82__net23 n113__net23 3.265e-3
rk1035 n8__i28__i71__net4 n7__i28__i71__net4 15.5
rk1036 n3__i28__i71__net5 n4__i28__i71__net5 38.041
rk1037 n26__i28__net3 n37__i28__net3 177e-3
rk1038 n11__i28__net23 n19__i28__net23 175.3e-3
rk1039 n80__net23 n115__net23 557e-3
rk1040 n2__i29__net23 n3__i29__net23 4.773e-3
rk1041 i29__net23 n2__i29__net23 75
rk1042 n2__net30 n3__net30 13.27e-3
rk1043 net30 n2__net30 31
rk1044 n132__clk100m_b n181__clk100m_b 2.658e-3
rk1046 n29__i28__net3 n38__i28__net3 500e-3
rk1047 n187__clk100m_b n130__clk100m_b 19.54e-3
rk1048 n92__vdd n93__vdd 2.601e-3
rk1049 n95__vdd n96__vdd 2.601e-3
rk1050 n92__vdd n96__vdd 15.28e-3
rk1051 n94__vdd n95__vdd 31
rk1052 n291__clk100m n209__clk100m 2.493e-3
rk1053 n57__net29 n95__net29 3.674e-3
rk1054 n389__clk1pt6g n472__clk1pt6g 3.265e-3
rk1055 net7 n3__net7 2.601e-3
rk1056 n4__net7 n5__net7 2.601e-3
rk1057 net7 n5__net7 15.28e-3
rk1058 n2__net7 n3__net7 31
rk1059 n166__rst n167__rst 6.895e-3
rk1060 n165__rst n166__rst 75
rk1061 n23__net9 n25__net9 6.895e-3
rk1062 n24__net9 n25__net9 75
rk1063 n108__rst n169__rst 3.265e-3
rk1064 n3__i29__i137__x n5__i29__i137__x 85.19e-3
rk1065 n5__i29__i137__x n6__i29__i137__x 75.2385
rk1066 n5__i29__i137__x n7__i29__i137__x 31.3419
rk1067 n294__clk100m n214__clk100m 504.5e-3
rk1068 n9__i33__i21__net1 n10__i33__i21__net1 75.3656
rk1069 n10__i33__i21__net1 n11__i33__i21__net1 31.0029
rk1070 n6__i28__i71__net5 n5__i28__i71__net5 37.5429
rk1074 n14__i28__i71__net4 i28__i71__net4 15.5
rk1075 n5__net30 n6__net30 852.8e-3
rk1076 n6__net30 n7__net30 75.1291
rk1077 n6__net30 n8__net30 31.2567
rk1078 n3__i33__i21__x n5__i33__i21__x 78.72e-3
rk1079 n5__i33__i21__x n6__i33__i21__x 75.2443
rk1080 n5__i33__i21__x n7__i33__i21__x 31.3568
rk1081 n5__i29__net23 n6__i29__net23 2.601e-3
rk1082 n7__i29__net23 n8__i29__net23 2.601e-3
rk1083 n6__i29__net23 n7__i29__net23 15.28e-3
rk1084 n4__i29__net23 n5__i29__net23 31
rk1085 n4__i40__i50__x n5__i40__i50__x 20.9555
rk1086 n5__i40__i50__x n2__i40__i50__x 45.1172
rk1087 n5__i40__i50__x n6__i40__i50__x 75.2238
rk1088 n12__net30 n13__net30 6.895e-3
rk1089 n11__net30 n12__net30 75
rk1090 n10__i28__net4 n11__i28__net4 15.7801
rk1091 n11__i28__net4 i28__net4 293.4e-3
rk1092 n11__i28__net4 n12__i28__net4 37.6764
rk1093 n401__clk1pt6g n483__clk1pt6g 4.773e-3
rk1094 n403__clk1pt6g n482__clk1pt6g 3.265e-3
rk1096 n119__net23 n85__net23 3.265e-3
rk1097 n7__i28__net12 n31__i28__net12 45.3157
rk1098 n31__i28__net12 n32__i28__net12 37.7383
rk1099 n31__i28__net12 n33__i28__net12 15.8225
rk1101 n109__rst_b n67__rst_b 9.796e-3
rk1102 n219__clk100m n299__clk100m 4.773e-3
rk1103 n221__clk100m n300__clk100m 2.658e-3
rk1105 n194__clk100m_b n138__clk100m_b 3.265e-3
rk1106 n485__clk1pt6g n400__clk1pt6g 3.674e-3
rk1107 n98__net29 n65__net29 3.265e-3
rk1108 n25__vss n26__vss 37.7872
rk1109 n26__vss n27__vss 430.9e-3
rk1110 n27__vss n28__vss 314.7e-3
rk1111 n28__vss n29__vss 163.5e-3
rk1112 n29__vss n30__vss 296.3e-3
rk1113 n30__vss n31__vss 312.5e-3
rk1114 n31__vss n32__vss 296.3e-3
rk1115 n32__vss n33__vss 296.3e-3
rk1116 n33__vss n34__vss 163.5e-3
rk1117 n34__vss n35__vss 296.3e-3
rk1118 n35__vss n36__vss 316.9e-3
rk1119 n36__vss n37__vss 296.3e-3
rk1120 n37__vss n38__vss 316.9e-3
rk1121 n38__vss n39__vss 296.3e-3
rk1122 n39__vss n40__vss 296.3e-3
rk1123 n40__vss n41__vss 316.9e-3
rk1124 n41__vss n42__vss 296.3e-3
rk1125 n42__vss n43__vss 160.2e-3
rk1126 n43__vss n44__vss 296.3e-3
rk1127 n44__vss n45__vss 296.3e-3
rk1128 n45__vss n46__vss 315.8e-3
rk1129 n46__vss n47__vss 297.7e-3
rk1130 n47__vss n48__vss 314.2e-3
rk1131 n48__vss n49__vss 296.3e-3
rk1132 n49__vss n50__vss 298.6e-3
rk1133 n50__vss n51__vss 312.7e-3
rk1134 n51__vss n20__vss 156.2e-3
rk1135 n26__vss n52__vss 37.8064
rk1136 n27__vss n53__vss 18.9763
rk1137 n28__vss n54__vss 18.9914
rk1138 n29__vss n55__vss 18.9914
rk1139 n30__vss n56__vss 18.9871
rk1140 n31__vss n57__vss 18.9871
rk1141 n32__vss n58__vss 18.9871
rk1142 n33__vss n59__vss 18.9914
rk1143 n34__vss n60__vss 18.9914
rk1144 n35__vss n61__vss 18.9871
rk1145 n36__vss n62__vss 18.9871
rk1146 n37__vss n63__vss 18.9871
rk1147 n38__vss n64__vss 18.9871
rk1148 n39__vss n65__vss 18.9871
rk1149 n40__vss n66__vss 18.9871
rk1150 n41__vss n67__vss 18.9871
rk1151 n42__vss n68__vss 18.9914
rk1152 n43__vss n69__vss 18.9914
rk1153 n44__vss n70__vss 18.9871
rk1154 n45__vss n71__vss 18.9871
rk1155 n46__vss n72__vss 18.9871
rk1156 n47__vss n73__vss 18.9871
rk1157 n48__vss n74__vss 18.9871
rk1158 n49__vss n75__vss 18.9871
rk1159 n50__vss n76__vss 18.9871
rk1160 n51__vss n77__vss 18.9819
rk1161 n20__vss n11__vss 20.909
rk1162 n9__i29__net23 n12__i29__net23 48.49e-3
rk1163 n12__i29__net23 n13__i29__net23 75.5577
rk1164 n11__i29__net23 n12__i29__net23 31
rk1165 n176__rst n178__rst 13.53e-3
rk1166 n178__rst n179__rst 349.6e-3
rk1168 n177__rst n178__rst 31
rk1169 n11__i28__net17 n12__i28__net17 529.8e-3
rk1170 n12__i28__net17 n13__i28__net17 37.6788
rk1171 n12__i28__net17 n14__i28__net17 15.7825
rk1172 i28__net2 n10__i28__net2 500e-3
rk1173 n13__net8 n14__net8 31.2956
rk1174 n14__net8 n15__net8 75.2544
rk1175 n7__net7 n6__net7 672.8e-3
rk1176 n6__net7 n8__net7 75.0029
rk1177 i28__net12 n34__i28__net12 500e-3
rk1178 n16__net8 n18__net8 13.27e-3
rk1179 n17__net8 n18__net8 31
rk1180 n100__vdd n101__vdd 3.382e-3
rk1181 n99__vdd n100__vdd 75
rk1182 n2__i29__net31 n4__i29__net31 508.6e-3
rk1183 n4__i29__net31 n5__i29__net31 31.2567
rk1184 n4__i29__net31 n6__i29__net31 75.1255
rk1185 n6__out8 n7__out8 20.9587
rk1186 n7__out8 n1__out8 91.08e-3
rk1187 n7__out8 n5__out8 60.67e-3
rk1188 n5__out8 n8__out8 75.1321
rk1189 n6__i33__i19__net1 n4__i33__i19__net1 6.34e-3
rk1190 n7__i33__i19__net1 n8__i33__i19__net1 6.314e-3
rk1191 n6__i33__i19__net1 n8__i33__i19__net1 26.25e-3
rk1192 n2__i33__i19__net1 n7__i33__i19__net1 45
rk1193 n407__clk1pt6g n492__clk1pt6g 3.014e-3
rk1195 n91__net23 n122__net23 3.265e-3
rk1197 n89__net23 n124__net23 557e-3
rk1198 n2__i29__net25 n3__i29__net25 4.773e-3
rk1199 i29__net25 n2__i29__net25 75
rk1200 n2__net31 n3__net31 13.27e-3
rk1201 net31 n2__net31 31
rk1202 n146__clk100m_b n197__clk100m_b 2.658e-3
rk1204 n11__i28__net2 n12__i28__net2 8.5735
rk1205 n13__i28__net2 n14__i28__net2 19.3792
rk1206 n201__clk100m_b n144__clk100m_b 19.54e-3
rk1207 n102__vdd n103__vdd 2.601e-3
rk1208 n105__vdd n106__vdd 2.601e-3
rk1209 n102__vdd n106__vdd 15.28e-3
rk1210 n104__vdd n105__vdd 31
rk1211 n307__clk100m n224__clk100m 2.493e-3
rk1212 n2__i28__i50__net1 n7__i28__i50__net1 45.5
rk1213 n66__net29 n104__net29 3.674e-3
rk1214 n408__clk1pt6g n498__clk1pt6g 3.265e-3
rk1215 net6 n3__net6 2.601e-3
rk1216 n4__net6 n5__net6 2.601e-3
rk1217 net6 n5__net6 15.28e-3
rk1218 n2__net6 n3__net6 31
rk1219 n182__rst n183__rst 6.895e-3
rk1220 n181__rst n182__rst 75
rk1221 n23__net8 n25__net8 6.895e-3
rk1222 n24__net8 n25__net8 75
rk1223 n124__rst n185__rst 3.265e-3
rk1224 n13__i28__net26 n14__i28__net26 538.6e-3
rk1225 n14__i28__net26 n15__i28__net26 37.682
rk1226 n14__i28__net26 n16__i28__net26 15.7792
rk1227 n15__i28__net7 n16__i28__net7 8.2586
rk1228 n16__i28__net7 n18__i28__net7 281.9e-3
rk1229 n16__i28__net7 n19__i28__net7 247.4e-3
rk1230 n19__i28__net7 n20__i28__net7 19.0045
rk1231 n18__i28__net7 n21__i28__net7 28.64e-3
rk1233 n19__i28__net7 n23__i28__net7 8.2064
rk1234 n17__i28__net7 n18__i28__net7 18.75
rk1235 n3__i29__i138__x n5__i29__i138__x 85.19e-3
rk1236 n5__i29__i138__x n6__i29__i138__x 75.2385
rk1237 n5__i29__i138__x n7__i29__i138__x 31.3419
rk1238 n310__clk100m n229__clk100m 504.5e-3
rk1239 n9__i33__i19__net1 n10__i33__i19__net1 75.3656
rk1240 n10__i33__i19__net1 n11__i33__i19__net1 31.0029
rk1241 n5__net31 n7__net31 352.8e-3
rk1242 n7__net31 n8__net31 75.1291
rk1243 n7__net31 n9__net31 31.2567
rk1244 n3__i33__i19__x n5__i33__i19__x 78.72e-3
rk1245 n5__i33__i19__x n6__i33__i19__x 75.2443
rk1246 n5__i33__i19__x n7__i33__i19__x 31.3568
rk1247 n5__i29__net25 n6__i29__net25 2.601e-3
rk1248 n7__i29__net25 n8__i29__net25 2.601e-3
rk1249 n6__i29__net25 n7__i29__net25 15.28e-3
rk1250 n4__i29__net25 n5__i29__net25 31
rk1251 n4__i40__i49__x n5__i40__i49__x 20.9555
rk1252 n5__i40__i49__x n2__i40__i49__x 45.1172
rk1253 n5__i40__i49__x n6__i40__i49__x 75.2238
rk1254 n12__net31 n13__net31 6.895e-3
rk1255 n11__net31 n12__net31 75
rk1256 n420__clk1pt6g n507__clk1pt6g 4.773e-3
rk1257 n422__clk1pt6g n506__clk1pt6g 3.265e-3
rk1259 n128__net23 n94__net23 3.265e-3
rk1261 n119__rst_b n77__rst_b 9.796e-3
rk1262 n234__clk100m n315__clk100m 4.773e-3
rk1263 n236__clk100m n316__clk100m 2.658e-3
rk1265 n208__clk100m_b n152__clk100m_b 3.265e-3
rk1266 n15__i28__net2 n16__i28__net2 8.5735
rk1267 n17__i28__net2 n18__i28__net2 19.3792
rk1268 n514__clk1pt6g n419__clk1pt6g 3.674e-3
rk1269 n109__net29 n74__net29 3.265e-3
rk1270 n5__i28__net19 n9__i28__net19 45.0612
rk1271 n9__i29__net25 n12__i29__net25 48.49e-3
rk1272 n12__i29__net25 n13__i29__net25 75.5577
rk1273 n11__i29__net25 n12__i29__net25 31
rk1274 n5__i28__i50__net1 n8__i28__i50__net1 45.5
rk1275 n192__rst n194__rst 13.53e-3
rk1276 n194__rst n195__rst 349.6e-3
rk1278 n193__rst n194__rst 31
rk1279 i28__i72__net3 n2__i28__i72__net3 38.0375
rk1280 n13__net7 n14__net7 31.2956
rk1281 n14__net7 n15__net7 75.2544
rk1283 n2__i28__i72__net2 n4__i28__i72__net2 42.96e-3
rk1284 n3__i28__i72__net2 n4__i28__i72__net2 15.5
rk1285 n7__net6 n6__net6 672.8e-3
rk1286 n6__net6 n8__net6 75.0029
rk1287 n16__net7 n18__net7 13.27e-3
rk1288 n17__net7 n18__net7 31
rk1289 n110__vdd n111__vdd 3.382e-3
rk1290 n109__vdd n110__vdd 75
rk1291 n2__i29__net11 n4__i29__net11 508.6e-3
rk1292 n4__i29__net11 n5__i29__net11 31.2567
rk1293 n4__i29__net11 n6__i29__net11 75.1255
rk1294 n6__out9 n7__out9 20.9587
rk1295 n7__out9 n1__out9 91.08e-3
rk1296 n7__out9 n5__out9 60.67e-3
rk1297 n5__out9 n8__out9 75.1321
rk1298 n6__i33__i22__net1 n4__i33__i22__net1 6.34e-3
rk1299 n7__i33__i22__net1 n8__i33__i22__net1 6.314e-3
rk1300 n6__i33__i22__net1 n8__i33__i22__net1 26.25e-3
rk1301 n2__i33__i22__net1 n7__i33__i22__net1 45
rk1302 n426__clk1pt6g n516__clk1pt6g 3.014e-3
rk1304 n100__net23 n131__net23 3.265e-3
rk1307 n6__i28__i72__net2 n8__i28__i72__net2 28.64e-3
rk1308 n7__i28__i72__net2 n8__i28__i72__net2 15.5
rk1309 n3__i28__i72__net3 n4__i28__i72__net3 38.041
rk1310 n98__net23 n133__net23 557e-3
rk1311 i28__i50__net2 n2__i28__i50__net2 8.2554
rk1312 n2__i28__i50__net2 n3__i28__i50__net2 273.4e-3
rk1313 n3__i28__i50__net2 n4__i28__i50__net2 266.9e-3
rk1314 n4__i28__i50__net2 n5__i28__i50__net2 19.0319
rk1315 n2__i28__i50__net2 n6__i28__i50__net2 19.0272
rk1316 n3__i28__i50__net2 n7__i28__i50__net2 19.0195
rk1317 n3__i28__i50__net2 n8__i28__i50__net2 8.243
rk1318 n4__i28__i50__net2 n9__i28__i50__net2 8.2586
rk1319 n2__i29__net12 n3__i29__net12 4.773e-3
rk1320 i29__net12 n2__i29__net12 75
rk1321 n2__net32 n3__net32 13.27e-3
rk1322 net32 n2__net32 31
rk1323 n5__i28__net26 n17__i28__net26 677e-3
rk1324 n22__i28__net12 n36__i28__net12 675.3e-3
rk1325 n160__clk100m_b n211__clk100m_b 2.658e-3
rk1327 n215__clk100m_b n158__clk100m_b 19.54e-3
rk1328 n112__vdd n113__vdd 2.601e-3
rk1329 n115__vdd n116__vdd 2.601e-3
rk1330 n112__vdd n116__vdd 15.28e-3
rk1331 n114__vdd n115__vdd 31
rk1332 n322__clk100m n263__clk100m 2.493e-3
rk1333 n75__net29 n113__net29 3.674e-3
rk1334 n427__clk1pt6g n522__clk1pt6g 3.265e-3
rk1336 n15__net5 n17__net5 2.601e-3
rk1337 n18__net5 n19__net5 2.601e-3
rk1338 n15__net5 n19__net5 15.28e-3
rk1339 n16__net5 n17__net5 31
rk1340 n198__rst n199__rst 6.895e-3
rk1341 n197__rst n198__rst 75
rk1342 n23__net7 n25__net7 6.895e-3
rk1343 n24__net7 n25__net7 75
rk1344 n140__rst n201__rst 3.265e-3
rk1345 n3__i29__i139__x n5__i29__i139__x 85.19e-3
rk1346 n5__i29__i139__x n6__i29__i139__x 75.2385
rk1347 n5__i29__i139__x n7__i29__i139__x 31.3419
rk1348 n325__clk100m n268__clk100m 4.494e-3
rk1349 n9__i33__i22__net1 n10__i33__i22__net1 75.3656
rk1350 n10__i33__i22__net1 n11__i33__i22__net1 31.0029
rk1351 n5__i28__i72__net3 n6__i28__i72__net3 38.0571
rk1353 i28__i72__net2 n12__i28__i72__net2 42.96e-3
rk1354 n11__i28__i72__net2 n12__i28__i72__net2 15.5
rk1355 n5__net32 n6__net32 852.8e-3
rk1356 n6__net32 n7__net32 75.1291
rk1357 n6__net32 n8__net32 31.2567
rk1358 n3__i33__i22__x n5__i33__i22__x 78.72e-3
rk1359 n5__i33__i22__x n6__i33__i22__x 75.2443
rk1360 n5__i33__i22__x n7__i33__i22__x 31.3568
rk1361 n5__i29__net12 n6__i29__net12 2.601e-3
rk1362 n7__i29__net12 n8__i29__net12 2.601e-3
rk1363 n6__i29__net12 n7__i29__net12 15.28e-3
rk1364 n4__i29__net12 n5__i29__net12 31
rk1365 n25__i28__net7 n24__i28__net7 662.8e-3
rk1366 n24__i28__net7 n2__i28__net7 45
rk1367 n4__i40__i48__x n5__i40__i48__x 20.9555
rk1368 n5__i40__i48__x n2__i40__i48__x 45.1172
rk1369 n5__i40__i48__x n6__i40__i48__x 75.2238
rk1370 n12__net32 n13__net32 6.895e-3
rk1371 n11__net32 n12__net32 75
rk1372 n439__clk1pt6g n533__clk1pt6g 4.773e-3
rk1373 n441__clk1pt6g n532__clk1pt6g 3.265e-3
rk1375 n137__net23 n103__net23 3.265e-3
rk1376 n9__i28__i50__net1 n11__i28__i50__net1 823.5e-3
rk1377 n11__i28__i50__net1 n13__i28__i50__net1 772.4e-3
rk1378 n13__i28__i50__net1 n14__i28__i50__net1 629.2e-3
rk1379 n10__i28__i50__net1 n11__i28__i50__net1 7.75
rk1380 n12__i28__i50__net1 n13__i28__i50__net1 18.75
rk1382 n129__rst_b n87__rst_b 9.796e-3
rk1383 n5__i28__i72__x n9__i28__i72__x 45.3066
rk1384 n9__i28__i72__x n10__i28__i72__x 37.7383
rk1385 n9__i28__i72__x n11__i28__i72__x 15.8225
rk1386 n273__clk100m n330__clk100m 4.773e-3
rk1387 n275__clk100m n331__clk100m 2.658e-3
rk1389 n222__clk100m_b n166__clk100m_b 3.265e-3
rk1390 n540__clk1pt6g n438__clk1pt6g 3.674e-3
rk1391 n118__net29 n83__net29 3.265e-3
rk1392 n9__i29__net12 n12__i29__net12 48.49e-3
rk1393 n12__i29__net12 n13__i29__net12 75.5577
rk1394 n11__i29__net12 n12__i29__net12 31
rk1395 n208__rst n210__rst 13.53e-3
rk1396 n210__rst n211__rst 349.6e-3
rk1398 n209__rst n210__rst 31
rk1402 n3__i28__i72__net4 n2__i28__i72__net4 15.5
rk1403 i28__i72__net5 n2__i28__i72__net5 38.0391
rk1404 n13__net6 n14__net6 31.2956
rk1405 n14__net6 n15__net6 75.2544
rk1406 n21__net5 n20__net5 672.8e-3
rk1407 n20__net5 n22__net5 75.0029
rk1408 n16__net6 n18__net6 13.27e-3
rk1409 n17__net6 n18__net6 31
rk1410 n120__vdd n121__vdd 3.382e-3
rk1411 n119__vdd n120__vdd 75
rk1412 n2__i29__net5 n4__i29__net5 508.6e-3
rk1413 n4__i29__net5 n5__i29__net5 31.2567
rk1414 n4__i29__net5 n6__i29__net5 75.1255
rk1415 n6__out10 n7__out10 20.9587
rk1416 n7__out10 n1__out10 91.08e-3
rk1417 n7__out10 n5__out10 60.67e-3
rk1418 n5__out10 n8__out10 75.1321
rk1422 n3__i28__i53__net4 n2__i28__i53__net4 15.5
rk1423 i28__i53__net5 n2__i28__i53__net5 38.041
rk1424 n6__i33__i17__net1 n4__i33__i17__net1 6.34e-3
rk1425 n7__i33__i17__net1 n8__i33__i17__net1 6.314e-3
rk1426 n6__i33__i17__net1 n8__i33__i17__net1 26.25e-3
rk1427 n2__i33__i17__net1 n7__i33__i17__net1 45
rk1428 n45__net22 n69__net22 500e-3
rk1429 n445__clk1pt6g n542__clk1pt6g 3.014e-3
rk1431 n109__net23 n140__net23 3.265e-3
rk1436 n8__i28__i72__net4 n7__i28__i72__net4 15.5
rk1437 n3__i28__i72__net5 n4__i28__i72__net5 38.041
rk1438 n28__i28__net12 n37__i28__net12 177e-3
rk1439 n11__i28__net26 n19__i28__net26 175.3e-3
rk1440 n17__i28__net8 n18__i28__net8 15.8092
rk1441 n18__i28__net8 n12__i28__net8 45.3169
rk1442 n18__i28__net8 n19__i28__net8 37.7513
rk1443 n107__net23 n142__net23 557e-3
rk1444 n2__i29__net6 n3__i29__net6 4.773e-3
rk1445 i29__net6 n2__i29__net6 75
rk1446 n2__net33 n3__net33 13.27e-3
rk1447 net33 n2__net33 31
rk1448 n174__clk100m_b n225__clk100m_b 2.658e-3
rk1450 n24__i28__net12 n38__i28__net12 500e-3
rk1451 n229__clk100m_b n172__clk100m_b 19.54e-3
rk1452 n122__vdd n123__vdd 2.601e-3
rk1453 n125__vdd n126__vdd 2.601e-3
rk1454 n122__vdd n126__vdd 15.28e-3
rk1455 n124__vdd n125__vdd 31
rk1456 n337__clk100m n278__clk100m 2.493e-3
rk1457 n84__net29 n122__net29 3.674e-3
rk1458 n446__clk1pt6g n548__clk1pt6g 3.265e-3
rk1459 net4 n3__net4 2.601e-3
rk1460 n4__net4 n5__net4 2.601e-3
rk1461 net4 n5__net4 15.28e-3
rk1462 n2__net4 n3__net4 31
rk1463 n214__rst n215__rst 6.895e-3
rk1464 n213__rst n214__rst 75
rk1465 n23__net6 n25__net6 6.895e-3
rk1466 n24__net6 n25__net6 75
rk1467 n156__rst n216__rst 3.265e-3
rk1468 n3__i28__i53__net5 n4__i28__i53__net5 38.041
rk1472 n8__i28__i53__net4 n7__i28__i53__net4 15.5
rk1473 n3__i29__i140__x n5__i29__i140__x 85.19e-3
rk1474 n5__i29__i140__x n6__i29__i140__x 75.2385
rk1475 n5__i29__i140__x n7__i29__i140__x 31.3419
rk1476 n338__clk100m n283__clk100m 504.5e-3
rk1477 n5__i28__i72__net5 n6__i28__i72__net5 38.0429
rk1481 n13__i28__i72__net4 i28__i72__net4 15.5
rk1482 n9__i33__i17__net1 n10__i33__i17__net1 75.3656
rk1483 n10__i33__i17__net1 n11__i33__i17__net1 31.0029
rk1484 n6__net33 n7__net33 352.8e-3
rk1485 n7__net33 n8__net33 75.1291
rk1486 n7__net33 n9__net33 31.2567
rk1487 n3__i33__i17__x n5__i33__i17__x 78.72e-3
rk1488 n5__i33__i17__x n6__i33__i17__x 75.2443
rk1489 n5__i33__i17__x n7__i33__i17__x 31.3568
rk1490 n5__i29__net6 n6__i29__net6 2.601e-3
rk1491 n7__i29__net6 n8__i29__net6 2.601e-3
rk1492 n6__i29__net6 n7__i29__net6 15.28e-3
rk1493 n4__i29__net6 n5__i29__net6 31
rk1494 n4__i40__i47__x n5__i40__i47__x 20.9555
rk1495 n5__i40__i47__x n2__i40__i47__x 45.1172
rk1496 n5__i40__i47__x n6__i40__i47__x 75.2238
rk1497 n51__net22 n72__net22 677e-3
rk1498 n450__clk1pt6g n550__clk1pt6g 675.3e-3
rk1499 n12__net33 n13__net33 6.895e-3
rk1500 n11__net33 n12__net33 75
rk1501 n463__clk1pt6g n551__clk1pt6g 4.773e-3
rk1502 n465__clk1pt6g n552__clk1pt6g 3.265e-3
rk1504 n146__net23 n112__net23 3.265e-3
rk1505 n7__i28__net13 n31__i28__net13 45.3157
rk1506 n31__i28__net13 n32__i28__net13 37.7383
rk1507 n31__i28__net13 n33__i28__net13 15.8225
rk1511 n13__i28__i53__net4 i28__i53__net4 15.5
rk1512 n5__i28__i53__net5 n6__i28__i53__net5 38.0391
rk1514 n134__rst_b n97__rst_b 9.796e-3
rk1515 n288__clk100m n343__clk100m 4.773e-3
rk1516 n290__clk100m n344__clk100m 2.658e-3
rk1518 n233__clk100m_b n180__clk100m_b 3.265e-3
rk1519 n555__clk1pt6g n462__clk1pt6g 3.674e-3
rk1520 n125__net29 n92__net29 3.265e-3
rk1521 n9__i29__net6 n12__i29__net6 48.49e-3
rk1522 n12__i29__net6 n13__i29__net6 75.5577
rk1523 n11__i29__net6 n12__i29__net6 31
rk1524 n219__rst n221__rst 13.53e-3
rk1525 n221__rst n222__rst 349.6e-3
rk1527 n220__rst n221__rst 31
rk1528 n11__i28__net19 n12__i28__net19 529.8e-3
rk1529 n12__i28__net19 n13__i28__net19 37.6788
rk1530 n12__i28__net19 n14__i28__net19 15.7825
rk1531 n25__net5 n26__net5 31.2956
rk1532 n26__net5 n27__net5 75.2544
rk1533 i28__net13 n34__i28__net13 500e-3
rk1534 n7__net4 n6__net4 672.8e-3
rk1535 n6__net4 n8__net4 75.0029
rk1536 n28__net5 n30__net5 13.27e-3
rk1537 n29__net5 n30__net5 31
rk1538 n130__vdd n131__vdd 3.382e-3
rk1539 n129__vdd n130__vdd 75
rk1540 n2__i29__net1 n4__i29__net1 508.6e-3
rk1541 n4__i29__net1 n5__i29__net1 31.2567
rk1542 n4__i29__net1 n6__i29__net1 75.1255
rk1544 n2__i28__i53__net2 n4__i28__i53__net2 28.64e-3
rk1545 n3__i28__i53__net2 n4__i28__i53__net2 15.5
rk1546 i28__i53__net3 n2__i28__i53__net3 38.0571
rk1547 n6__out11 n7__out11 20.9587
rk1548 n7__out11 n1__out11 91.08e-3
rk1549 n7__out11 n5__out11 60.67e-3
rk1550 n5__out11 n8__out11 75.1321
rk1551 n6__i33__i18__net1 n4__i33__i18__net1 6.34e-3
rk1552 n7__i33__i18__net1 n8__i33__i18__net1 6.314e-3
rk1553 n6__i33__i18__net1 n8__i33__i18__net1 26.25e-3
rk1554 n2__i33__i18__net1 n7__i33__i18__net1 45
rk1555 n474__clk1pt6g n562__clk1pt6g 500e-3
rk1556 n469__clk1pt6g n563__clk1pt6g 3.014e-3
rk1558 n118__net23 n149__net23 3.265e-3
rk1560 n9__i28__i53__x n10__i28__i53__x 15.8225
rk1561 n10__i28__i53__x i28__i53__x 45.3066
rk1562 n10__i28__i53__x n11__i28__i53__x 37.7383
rk1563 n116__net23 n151__net23 557e-3
rk1564 n2__i29__net34 n3__i29__net34 4.773e-3
rk1565 i29__net34 n2__i29__net34 75
rk1566 n2__net34 n3__net34 13.27e-3
rk1567 net34 n2__net34 31
rk1568 n190__clk100m_b n234__clk100m_b 2.658e-3
rk1570 n236__clk100m_b n188__clk100m_b 19.54e-3
rk1571 n132__vdd n133__vdd 2.601e-3
rk1572 n135__vdd n136__vdd 2.601e-3
rk1573 n132__vdd n136__vdd 15.28e-3
rk1574 n134__vdd n135__vdd 31
rk1575 n347__clk100m n293__clk100m 2.493e-3
rk1576 n93__net29 n130__net29 3.674e-3
rk1577 n470__clk1pt6g n571__clk1pt6g 3.265e-3
rk1578 net3 n3__net3 2.601e-3
rk1579 n4__net3 n5__net3 2.601e-3
rk1580 net3 n5__net3 15.28e-3
rk1581 n2__net3 n3__net3 31
rk1582 n225__rst n226__rst 6.895e-3
rk1583 n224__rst n225__rst 75
rk1584 n37__net5 n39__net5 6.895e-3
rk1585 n38__net5 n39__net5 75
rk1586 n3__i28__i53__net3 n4__i28__i53__net3 38.041
rk1588 n6__i28__i53__net2 n8__i28__i53__net2 28.64e-3
rk1589 n7__i28__i53__net2 n8__i28__i53__net2 15.5
rk1590 n172__rst n227__rst 3.265e-3
rk1591 n13__i28__net11 n14__i28__net11 538.6e-3
rk1592 n14__i28__net11 n15__i28__net11 37.682
rk1593 n14__i28__net11 n16__i28__net11 15.7792
rk1594 n3__i29__i141__x n5__i29__i141__x 85.19e-3
rk1595 n5__i29__i141__x n6__i29__i141__x 75.2385
rk1596 n5__i29__i141__x n7__i29__i141__x 31.3419
rk1597 n348__clk100m n298__clk100m 504.5e-3
rk1598 n9__i33__i18__net1 n10__i33__i18__net1 75.3656
rk1599 n10__i33__i18__net1 n11__i33__i18__net1 31.0029
rk1600 n480__clk1pt6g n572__clk1pt6g 677e-3
rk1601 n52__net22 n73__net22 675.3e-3
rk1602 n5__net34 n6__net34 852.8e-3
rk1603 n6__net34 n7__net34 75.1291
rk1604 n6__net34 n8__net34 31.2567
rk1605 n3__i33__i18__x n5__i33__i18__x 78.72e-3
rk1606 n5__i33__i18__x n6__i33__i18__x 75.2443
rk1607 n5__i33__i18__x n7__i33__i18__x 31.3568
rk1608 n5__i29__net34 n6__i29__net34 2.601e-3
rk1609 n7__i29__net34 n8__i29__net34 2.601e-3
rk1610 n6__i29__net34 n7__i29__net34 15.28e-3
rk1611 n4__i29__net34 n5__i29__net34 31
rk1612 n4__i40__i46__x n5__i40__i46__x 20.9555
rk1613 n5__i40__i46__x n2__i40__i46__x 45.1172
rk1614 n5__i40__i46__x n6__i40__i46__x 75.2238
rk1615 n11__net34 n12__net34 6.895e-3
rk1616 n10__net34 n11__net34 75
rk1617 n489__clk1pt6g n574__clk1pt6g 4.773e-3
rk1618 n491__clk1pt6g n575__clk1pt6g 3.265e-3
rk1620 n155__net23 n121__net23 3.265e-3
rk1622 i28__i53__net2 n12__i28__i53__net2 28.64e-3
rk1623 n11__i28__i53__net2 n12__i28__i53__net2 15.5
rk1624 n5__i28__i53__net3 n6__i28__i53__net3 38.0375
rk1626 n141__rst_b n107__rst_b 9.796e-3
rk1627 n304__clk100m n350__clk100m 4.773e-3
rk1628 n306__clk100m n351__clk100m 2.658e-3
rk1630 n239__clk100m_b n196__clk100m_b 3.265e-3
rk1631 n578__clk1pt6g n488__clk1pt6g 3.674e-3
rk1632 n133__net29 n101__net29 3.265e-3
rk1633 n5__i28__net5 n9__i28__net5 45.5612
rk1634 n9__i29__net34 n11__i29__net34 48.49e-3
rk1635 n11__i29__net34 n12__i29__net34 75.5577
rk1636 n10__i29__net34 n11__i29__net34 31
rk1637 n230__rst n232__rst 13.53e-3
rk1638 n232__rst n233__rst 349.6e-3
rk1640 n231__rst n232__rst 31
rk1641 i28__i51__net3 n2__i28__i51__net3 38.0375
rk1643 n2__i28__i51__net2 n4__i28__i51__net2 42.96e-3
rk1644 n3__i28__i51__net2 n4__i28__i51__net2 15.5
rk1645 n13__net4 n14__net4 31.2956
rk1646 n14__net4 n15__net4 75.2544
rk1647 n7__net3 n6__net3 672.8e-3
rk1648 n6__net3 n8__net3 75.0029
rk1649 n16__net4 n18__net4 13.27e-3
rk1650 n17__net4 n18__net4 31
rk1651 n140__vdd n141__vdd 3.382e-3
rk1652 n139__vdd n140__vdd 75
rk1653 n2__i29__net2 n4__i29__net2 508.6e-3
rk1654 n4__i29__net2 n5__i29__net2 31.2567
rk1655 n4__i29__net2 n6__i29__net2 75.1255
rk1659 n3__i28__i52__net4 n2__i28__i52__net4 15.5
rk1660 i28__i52__net5 n2__i28__i52__net5 38.041
rk1661 n6__out12 n7__out12 20.9587
rk1662 n7__out12 n1__out12 91.08e-3
rk1663 n7__out12 n5__out12 60.67e-3
rk1664 n5__out12 n8__out12 75.1321
rk1665 n57__net22 n74__net22 500e-3
rk1666 n4__i33__i16__net1 n5__i33__i16__net1 6.34e-3
rk1667 n6__i33__i16__net1 n7__i33__i16__net1 6.314e-3
rk1668 n4__i33__i16__net1 n7__i33__i16__net1 26.25e-3
rk1669 n2__i33__i16__net1 n6__i33__i16__net1 45
rk1670 n29__i28__net7 n30__i28__net7 15.8297
rk1671 n30__i28__net7 n27__i28__net7 131.4e-3
rk1672 n27__i28__net7 n7__i28__net7 45.1762
rk1673 n30__i28__net7 n31__i28__net7 37.7325
rk1674 n495__clk1pt6g n585__clk1pt6g 3.014e-3
rk1676 n127__net23 n158__net23 3.265e-3
rk1679 n6__i28__i51__net2 n8__i28__i51__net2 28.64e-3
rk1680 n7__i28__i51__net2 n8__i28__i51__net2 15.5
rk1681 n3__i28__i51__net3 n4__i28__i51__net3 38.041
rk1682 n125__net23 n160__net23 557e-3
rk1683 n5__i28__net11 n17__i28__net11 677e-3
rk1684 n22__i28__net13 n36__i28__net13 675.3e-3
rk1685 n2__i29__net18 n3__i29__net18 4.773e-3
rk1686 i29__net18 n2__i29__net18 75
rk1687 n2__net35 n3__net35 13.27e-3
rk1688 net35 n2__net35 31
rk1689 n204__clk100m_b n240__clk100m_b 2.658e-3
rk1691 n242__clk100m_b n202__clk100m_b 19.54e-3
rk1692 n142__vdd n143__vdd 2.601e-3
rk1693 n145__vdd n146__vdd 2.601e-3
rk1694 n142__vdd n146__vdd 15.28e-3
rk1695 n144__vdd n145__vdd 31
rk1696 i28__net11 n18__i28__net11 500e-3
rk1697 n354__clk100m n309__clk100m 2.493e-3
rk1698 n102__net29 n137__net29 3.674e-3
rk1699 n496__clk1pt6g n587__clk1pt6g 3.265e-3
rk1700 n3__i28__i52__net5 n4__i28__i52__net5 38.041
rk1704 n8__i28__i52__net4 n7__i28__i52__net4 15.5
rk1705 net2 n3__net2 2.601e-3
rk1706 n4__net2 n5__net2 2.601e-3
rk1707 net2 n5__net2 15.28e-3
rk1708 n2__net2 n3__net2 31
rk1709 n236__rst n237__rst 6.895e-3
rk1710 n235__rst n236__rst 75
rk1711 n22__net4 n24__net4 6.895e-3
rk1712 n23__net4 n24__net4 75
rk1713 n188__rst n238__rst 3.265e-3
rk1714 n3__i29__i142__x n5__i29__i142__x 85.19e-3
rk1715 n5__i29__i142__x n6__i29__i142__x 75.2385
rk1716 n5__i29__i142__x n7__i29__i142__x 31.3419
rk1717 n355__clk100m n314__clk100m 504.5e-3
rk1718 n9__i33__i16__net1 n10__i33__i16__net1 75.3656
rk1719 n10__i33__i16__net1 n11__i33__i16__net1 31.0029
rk1720 n63__net22 n76__net22 677e-3
rk1721 n500__clk1pt6g n588__clk1pt6g 675.3e-3
rk1722 n5__i28__i51__net3 n6__i28__i51__net3 38.0571
rk1724 i28__i51__net2 n12__i28__i51__net2 42.96e-3
rk1725 n11__i28__i51__net2 n12__i28__i51__net2 15.5
rk1726 n4__net35 n5__net35 852.8e-3
rk1727 n5__net35 n6__net35 75.1291
rk1728 n5__net35 n7__net35 31.2567
rk1729 n3__i33__i16__x n5__i33__i16__x 78.72e-3
rk1730 n5__i33__i16__x n6__i33__i16__x 75.2443
rk1731 n5__i33__i16__x n7__i33__i16__x 31.3568
rk1732 n5__i29__net18 n6__i29__net18 2.601e-3
rk1733 n7__i29__net18 n8__i29__net18 2.601e-3
rk1734 n6__i29__net18 n7__i29__net18 15.28e-3
rk1735 n4__i29__net18 n5__i29__net18 31
rk1736 n4__i40__i45__x n5__i40__i45__x 20.9555
rk1737 n5__i40__i45__x n2__i40__i45__x 45.1172
rk1738 n5__i40__i45__x n6__i40__i45__x 75.2238
rk1739 n9__net35 n10__net35 6.895e-3
rk1740 n8__net35 n9__net35 75
rk1744 n13__i28__i52__net4 i28__i52__net4 15.5
rk1745 n5__i28__i52__net5 n6__i28__i52__net5 38.0391
rk1746 n511__clk1pt6g n589__clk1pt6g 4.773e-3
rk1747 n513__clk1pt6g n590__clk1pt6g 3.265e-3
rk1749 n161__net23 n130__net23 3.265e-3
rk1751 n147__rst_b n117__rst_b 9.796e-3
rk1752 n5__i28__i51__x n9__i28__i51__x 45.3066
rk1753 n9__i28__i51__x n10__i28__i51__x 37.7383
rk1754 n9__i28__i51__x n11__i28__i51__x 15.8225
rk1755 n319__clk100m n356__clk100m 4.773e-3
rk1756 n321__clk100m n357__clk100m 2.658e-3
rk1758 n243__clk100m_b n210__clk100m_b 3.265e-3
rk1759 n592__clk1pt6g n510__clk1pt6g 3.674e-3
rk1760 n138__net29 n108__net29 3.265e-3
rk1761 n9__i29__net18 n11__i29__net18 48.49e-3
rk1762 n11__i29__net18 n12__i29__net18 75.5577
rk1763 n10__i29__net18 n11__i29__net18 31
rk1764 n239__rst n241__rst 13.53e-3
rk1765 n241__rst n242__rst 349.6e-3
rk1767 n240__rst n241__rst 31
rk1771 n3__i28__i51__net4 n2__i28__i51__net4 15.5
rk1772 i28__i51__net5 n2__i28__i51__net5 38.0391
rk1773 n10__net3 n11__net3 31.2956
rk1774 n11__net3 n12__net3 75.2544
rk1775 n6__net2 n7__net2 672.8e-3
rk1776 n7__net2 n8__net2 75.0029
rk1778 n2__i28__i52__net2 n4__i28__i52__net2 28.64e-3
rk1779 n3__i28__i52__net2 n4__i28__i52__net2 15.5
rk1780 i28__i52__net3 n2__i28__i52__net3 38.0571
rk1781 n13__net3 n15__net3 13.27e-3
rk1782 n14__net3 n15__net3 31
rk1783 n148__vdd n149__vdd 3.382e-3
rk1784 n147__vdd n148__vdd 75
rk1785 n2__i29__net3 n4__i29__net3 508.6e-3
rk1786 n4__i29__net3 n5__i29__net3 31.2567
rk1787 n4__i29__net3 n6__i29__net3 75.1255
rk1788 n524__clk1pt6g n593__clk1pt6g 500e-3
rk1789 n5__out13 n6__out13 20.9587
rk1790 n6__out13 n1__out13 91.08e-3
rk1791 n6__out13 n7__out13 60.67e-3
rk1792 n7__out13 n8__out13 75.1321
rk1793 n4__i33__i0__net1 n5__i33__i0__net1 6.34e-3
rk1794 n6__i33__i0__net1 n7__i33__i0__net1 6.314e-3
rk1795 n4__i33__i0__net1 n7__i33__i0__net1 26.25e-3
rk1796 n2__i33__i0__net1 n6__i33__i0__net1 45
rk1797 n9__i28__i52__x n10__i28__i52__x 15.8225
rk1798 n10__i28__i52__x i28__i52__x 45.3066
rk1799 n10__i28__i52__x n11__i28__i52__x 37.7383
rk1803 n8__i28__i51__net4 n7__i28__i51__net4 15.5
rk1804 n3__i28__i51__net5 n4__i28__i51__net5 38.041
rk1805 n519__clk1pt6g n594__clk1pt6g 3.014e-3
rk1807 n136__net23 n162__net23 3.265e-3
rk1809 n28__i28__net13 n37__i28__net13 677e-3
rk1810 n11__i28__net11 n19__i28__net11 675.3e-3
rk1811 n134__net23 n164__net23 557e-3
rk1812 n2__i29__net13 n3__i29__net13 4.773e-3
rk1813 i29__net13 n2__i29__net13 75
rk1814 n2__net36 n3__net36 13.27e-3
rk1815 net36 n2__net36 31
rk1816 n218__clk100m_b n244__clk100m_b 2.658e-3
rk1818 n24__i28__net13 n38__i28__net13 500e-3
rk1819 n3__i28__i52__net3 n4__i28__i52__net3 38.041
rk1821 n6__i28__i52__net2 n8__i28__i52__net2 28.64e-3
rk1822 n7__i28__i52__net2 n8__i28__i52__net2 15.5
rk1823 n246__clk100m_b n216__clk100m_b 19.54e-3
rk1824 n150__vdd n151__vdd 2.601e-3
rk1825 n153__vdd n154__vdd 2.601e-3
rk1826 n150__vdd n154__vdd 15.28e-3
rk1827 n152__vdd n153__vdd 31
rk1828 n359__clk100m n324__clk100m 2.493e-3
rk1829 n111__net29 n139__net29 3.674e-3
rk1830 n520__clk1pt6g n596__clk1pt6g 3.265e-3
rk1831 n5__i33__d0 n7__i33__d0 2.601e-3
rk1832 n8__i33__d0 n9__i33__d0 2.601e-3
rk1833 n5__i33__d0 n9__i33__d0 15.28e-3
rk1834 n6__i33__d0 n7__i33__d0 31
rk1835 n245__rst n246__rst 6.895e-3
rk1836 n244__rst n245__rst 75
rk1837 n16__net3 n18__net3 6.895e-3
rk1838 n17__net3 n18__net3 75
rk1839 n204__rst n247__rst 3.265e-3
rk1840 n206__rst n190__rst 1.0365
rk1841 n190__rst n174__rst 1.0365
rk1842 n174__rst n158__rst 1.0365
rk1843 n158__rst n142__rst 1.0365
rk1844 n142__rst n126__rst 1.0365
rk1845 n126__rst n110__rst 1.0365
rk1846 n110__rst n94__rst 1.0365
rk1847 n94__rst n78__rst 1.0365
rk1848 n78__rst n62__rst 1.0365
rk1849 n62__rst n46__rst 1.0365
rk1850 n46__rst n30__rst 1.0365
rk1851 n30__rst n20__rst 1.0365
rk1852 n20__rst n15__rst 1.0365
rk1853 n15__rst n10__rst 1.0365
rk1854 n10__rst n5__rst 1.0325
rk1855 n5__rst rst 24.29e-3
rk1856 n530__clk1pt6g n597__clk1pt6g 677e-3
rk1857 n64__net22 n77__net22 675.3e-3
rk1858 n3__i29__i143__x n5__i29__i143__x 85.19e-3
rk1859 n5__i29__i143__x n6__i29__i143__x 75.2385
rk1860 n5__i29__i143__x n7__i29__i143__x 31.3419
rk1861 n360__clk100m n329__clk100m 504.5e-3
rk1862 n5__i28__i51__net5 n6__i28__i51__net5 38.0429
rk1866 n13__i28__i51__net4 i28__i51__net4 15.5
rk1867 n8__i33__i0__net1 n9__i33__i0__net1 75.3656
rk1868 n9__i33__i0__net1 n10__i33__i0__net1 31.0029
rk1869 n4__net36 n5__net36 852.8e-3
rk1870 n5__net36 n6__net36 75.1291
rk1871 n5__net36 n7__net36 31.2567
rk1872 n3__i33__i0__x n5__i33__i0__x 78.72e-3
rk1873 n5__i33__i0__x n6__i33__i0__x 75.2443
rk1874 n5__i33__i0__x n7__i33__i0__x 31.3568
rk1875 n5__i29__net13 n6__i29__net13 2.601e-3
rk1876 n7__i29__net13 n8__i29__net13 2.601e-3
rk1877 n6__i29__net13 n7__i29__net13 15.28e-3
rk1878 n4__i29__net13 n5__i29__net13 31
rk1879 n4__i40__i44__x n5__i40__i44__x 20.9555
rk1880 n5__i40__i44__x n2__i40__i44__x 45.1172
rk1881 n5__i40__i44__x n6__i40__i44__x 75.2238
rk1883 i28__i52__net2 n12__i28__i52__net2 28.64e-3
rk1884 n11__i28__i52__net2 n12__i28__i52__net2 15.5
rk1885 n5__i28__i52__net3 n6__i28__i52__net3 38.0375
rk1886 n9__net36 n10__net36 6.895e-3
rk1887 n8__net36 n9__net36 75
rk1888 n537__clk1pt6g n598__clk1pt6g 4.773e-3
rk1889 n539__clk1pt6g n599__clk1pt6g 3.265e-3
rk1891 n165__net23 n139__net23 3.265e-3
rk1892 n13__i28__net6 n18__i28__net6 45.3157
rk1893 n18__i28__net6 n19__i28__net6 37.7383
rk1894 n18__i28__net6 n20__i28__net6 15.8225
rk1896 n149__rst_b n127__rst_b 9.796e-3
rk1897 n334__clk100m n361__clk100m 4.773e-3
rk1898 n336__clk100m n362__clk100m 2.658e-3
rk1900 n247__clk100m_b n224__clk100m_b 3.265e-3
rk1901 n601__clk1pt6g n536__clk1pt6g 3.674e-3
rk1902 n140__net29 n117__net29 3.265e-3
rk1903 n10__i33__d0 n12__i33__d0 2.939e-3
rk1904 n11__i33__d0 n12__i33__d0 75
rk1905 n9__i29__net13 n11__i29__net13 48.49e-3
rk1906 n11__i29__net13 n12__i29__net13 75.5577
rk1907 n10__i29__net13 n11__i29__net13 31
rk1908 n248__rst n250__rst 13.53e-3
rk1909 n250__rst n251__rst 349.6e-3
rk1911 n249__rst n250__rst 31
rk1912 n11__i28__net5 n12__i28__net5 529.8e-3
rk1913 n12__i28__net5 n13__i28__net5 37.6788
rk1914 n12__i28__net5 n14__i28__net5 15.7825
rk1915 n9__net2 n10__net2 31.2935
rk1916 n10__net2 n11__net2 75.2564
rk1918 n156__vdd n157__vdd 334.3e-3
rk1919 n157__vdd n158__vdd 137.6e-3
rk1920 n158__vdd n159__vdd 509.7e-3
rk1921 n159__vdd n160__vdd 334.3e-3
rk1922 n160__vdd n161__vdd 137.6e-3
rk1923 n161__vdd n162__vdd 509.7e-3
rk1924 n162__vdd n163__vdd 334.3e-3
rk1925 n163__vdd n164__vdd 137.6e-3
rk1926 n164__vdd n165__vdd 509.7e-3
rk1927 n165__vdd n166__vdd 334.3e-3
rk1928 n166__vdd n167__vdd 137.6e-3
rk1929 n167__vdd n168__vdd 509.7e-3
rk1930 n168__vdd n169__vdd 334.3e-3
rk1931 n169__vdd n170__vdd 137.6e-3
rk1932 n170__vdd n171__vdd 509.7e-3
rk1933 n171__vdd n172__vdd 334.3e-3
rk1934 n172__vdd n173__vdd 137.6e-3
rk1935 n173__vdd n174__vdd 509.7e-3
rk1936 n174__vdd n175__vdd 334.3e-3
rk1937 n175__vdd n176__vdd 137.6e-3
rk1938 n176__vdd n177__vdd 509.7e-3
rk1939 n177__vdd n178__vdd 334.3e-3
rk1940 n178__vdd n179__vdd 137.6e-3
rk1941 n179__vdd n180__vdd 509.7e-3
rk1942 n180__vdd n181__vdd 334.3e-3
rk1943 n181__vdd n182__vdd 137.6e-3
rk1944 n182__vdd n183__vdd 509.7e-3
rk1945 n183__vdd n184__vdd 334.3e-3
rk1946 n184__vdd n185__vdd 137.6e-3
rk1947 n185__vdd n186__vdd 474.6e-3
rk1948 n186__vdd n187__vdd 334.3e-3
rk1949 n187__vdd n188__vdd 137.6e-3
rk1950 n188__vdd n189__vdd 509.7e-3
rk1951 n189__vdd n190__vdd 334.3e-3
rk1952 n190__vdd n191__vdd 137.6e-3
rk1953 n191__vdd n192__vdd 509.7e-3
rk1954 n192__vdd n193__vdd 334.3e-3
rk1955 n193__vdd n194__vdd 137.6e-3
rk1956 n194__vdd n195__vdd 509.7e-3
rk1957 n195__vdd n196__vdd 334.3e-3
rk1958 n196__vdd n197__vdd 137.6e-3
rk1959 n197__vdd n198__vdd 509.7e-3
rk1960 n198__vdd n199__vdd 334.3e-3
rk1961 n199__vdd n200__vdd 137.6e-3
rk1962 n200__vdd n201__vdd 509.3e-3
rk1963 n201__vdd n202__vdd 334.3e-3
rk1964 n202__vdd n203__vdd 137.6e-3
rk1965 n203__vdd n204__vdd 997.6e-3
rk1966 n204__vdd n205__vdd 215.3e-3
rk1967 n205__vdd n206__vdd 169.8e-3
rk1968 n206__vdd n207__vdd 326.9e-3
rk1969 n207__vdd n208__vdd 213.7e-3
rk1970 n208__vdd n209__vdd 213.7e-3
rk1971 n209__vdd n210__vdd 31.5274
rk1972 n156__vdd n211__vdd 31.1399
rk1973 n157__vdd n212__vdd 75.114
rk1974 n158__vdd n213__vdd 31.1326
rk1975 n159__vdd n214__vdd 31.1399
rk1976 n160__vdd n212__vdd 75.114
rk1977 n161__vdd n215__vdd 31.1326
rk1978 n162__vdd n216__vdd 31.1399
rk1979 n163__vdd n212__vdd 75.114
rk1980 n164__vdd n217__vdd 31.1326
rk1981 n165__vdd n218__vdd 31.1399
rk1982 n166__vdd n212__vdd 75.114
rk1983 n167__vdd n219__vdd 31.1326
rk1984 n168__vdd n220__vdd 31.1399
rk1985 n169__vdd n212__vdd 75.114
rk1986 n170__vdd n221__vdd 31.1326
rk1987 n171__vdd n222__vdd 31.1399
rk1988 n172__vdd n212__vdd 75.114
rk1989 n173__vdd n223__vdd 31.1326
rk1990 n174__vdd n224__vdd 31.1399
rk1991 n175__vdd n212__vdd 75.114
rk1992 n176__vdd n225__vdd 31.1326
rk1993 n177__vdd n226__vdd 31.1399
rk1994 n178__vdd n212__vdd 75.114
rk1995 n179__vdd n227__vdd 31.1326
rk1996 n180__vdd n228__vdd 31.1399
rk1997 n181__vdd n212__vdd 75.114
rk1998 n182__vdd n229__vdd 31.1326
rk1999 n183__vdd n230__vdd 31.1399
rk2000 n184__vdd n212__vdd 75.114
rk2001 n185__vdd n231__vdd 31.1326
rk2002 n186__vdd n232__vdd 31.1399
rk2003 n187__vdd n212__vdd 75.114
rk2004 n188__vdd n233__vdd 31.1326
rk2005 n189__vdd n234__vdd 31.1399
rk2006 n190__vdd n212__vdd 75.114
rk2007 n191__vdd n235__vdd 31.1326
rk2008 n192__vdd n236__vdd 31.1399
rk2009 n193__vdd n212__vdd 75.114
rk2010 n194__vdd n237__vdd 31.1326
rk2011 n195__vdd n238__vdd 31.1399
rk2012 n196__vdd n212__vdd 75.114
rk2013 n197__vdd n239__vdd 31.1326
rk2014 n198__vdd n240__vdd 31.1399
rk2015 n199__vdd n212__vdd 75.114
rk2016 n200__vdd n241__vdd 31.1326
rk2017 n201__vdd n242__vdd 31.1399
rk2018 n202__vdd n212__vdd 75.114
rk2019 n203__vdd n243__vdd 31.1635
rk2020 n204__vdd n1__vdd 327.4e-3
rk2021 n205__vdd n244__vdd 88.98e-3
rk2022 n244__vdd n212__vdd 75.1399
rk2023 n206__vdd n245__vdd 31.1552
rk2024 n207__vdd n246__vdd 31.1291
rk2025 n208__vdd n212__vdd 75.1399
rk2026 n209__vdd n247__vdd 31.1291
rk2027 n244__vdd n248__vdd 189.8e-3
rk2028 n248__vdd n249__vdd 31.1291
rk2029 n248__vdd n250__vdd 31.4887
rk2030 n12__net2 n14__net2 13.27e-3
rk2031 n13__net2 n14__net2 31
rk2032 n252__vdd n253__vdd 3.382e-3
rk2033 n251__vdd n252__vdd 75
rk2034 n2__i29__net4 n4__i29__net4 508.6e-3
rk2035 n4__i29__net4 n5__i29__net4 31.2567
rk2036 n4__i29__net4 n6__i29__net4 75.1255
rk2037 n47__en_b n44__en_b 1.0365
rk2038 n44__en_b n41__en_b 1.0365
rk2039 n41__en_b n38__en_b 1.0365
rk2040 n38__en_b n35__en_b 1.0365
rk2041 n35__en_b n32__en_b 1.0365
rk2042 n32__en_b n29__en_b 1.0365
rk2043 n29__en_b n26__en_b 1.0365
rk2044 n26__en_b n23__en_b 1.0365
rk2045 n23__en_b n20__en_b 1.0365
rk2046 n20__en_b n17__en_b 1.0365
rk2047 n17__en_b n14__en_b 1.0365
rk2048 n14__en_b n11__en_b 1.0365
rk2049 n11__en_b n8__en_b 1.0365
rk2050 n8__en_b n5__en_b 1.0365
rk2051 n5__en_b n1__en_b 1.0165
rk2052 n5__out14 n6__out14 20.9587
rk2053 n6__out14 n1__out14 91.08e-3
rk2054 n6__out14 n7__out14 60.67e-3
rk2055 n7__out14 n8__out14 75.1321
rk2056 n9__i28__net6 n21__i28__net6 500e-3
rk2057 i28__net6 n22__i28__net6 45.8767
rk2058 n545__clk1pt6g n602__clk1pt6g 3.014e-3
rk2060 n145__net23 n166__net23 3.265e-3
rk2062 n47__en n44__en 1.3429
rk2063 n44__en n41__en 1.3821
rk2064 n41__en n38__en 1.3821
rk2065 n38__en n35__en 1.3821
rk2066 n35__en n32__en 1.3821
rk2067 n32__en n29__en 1.3821
rk2068 n29__en n26__en 1.3564
rk2069 n26__en n23__en 1.1418
rk2070 n23__en n20__en 1.3821
rk2071 n20__en n17__en 1.3821
rk2072 n17__en n14__en 1.3821
rk2073 n14__en n11__en 1.3821
rk2074 n11__en n8__en 1.3564
rk2075 n8__en n5__en 1.1418
rk2076 n5__en n1__en 1.3821
rk2077 n143__net23 n168__net23 557e-3
rk2078 n2__i29__net7 n3__i29__net7 4.773e-3
rk2079 i29__net7 n2__i29__net7 75
rk2080 n2__net37 n3__net37 13.27e-3
rk2081 net37 n2__net37 31
rk2082 n254__vdd n255__vdd 2.601e-3
rk2083 n257__vdd n258__vdd 2.601e-3
rk2084 n254__vdd n258__vdd 15.28e-3
rk2085 n256__vdd n257__vdd 31
rk2086 n120__net29 n141__net29 3.674e-3
rk2087 n546__clk1pt6g n604__clk1pt6g 3.265e-3
rk2088 n6__net21 n10__net21 729.6e-3
rk2089 n15__net2 n17__net2 6.895e-3
rk2090 n16__net2 n17__net2 75
rk2091 n3__i29__i144__x n5__i29__i144__x 85.19e-3
rk2092 n5__i29__i144__x n6__i29__i144__x 75.2385
rk2093 n5__i29__i144__x n7__i29__i144__x 31.3419
rk2094 n364__clk100m n342__clk100m 504.5e-3
rk2095 n4__net37 n5__net37 852.8e-3
rk2096 n5__net37 n6__net37 75.1291
rk2097 n5__net37 n7__net37 31.2567
rk2099 n260__vdd n261__vdd 139.9e-3
rk2100 n261__vdd n262__vdd 872.9e-3
rk2101 n262__vdd n263__vdd 161.2e-3
rk2102 n263__vdd n264__vdd 882.9e-3
rk2103 n264__vdd n265__vdd 161.2e-3
rk2104 n265__vdd n266__vdd 882.9e-3
rk2105 n266__vdd n138__vdd 161.2e-3
rk2106 n138__vdd n267__vdd 882.9e-3
rk2107 n267__vdd n128__vdd 161.2e-3
rk2108 n128__vdd n268__vdd 882.9e-3
rk2109 n268__vdd n118__vdd 161.2e-3
rk2110 n118__vdd n269__vdd 882.9e-3
rk2111 n269__vdd n108__vdd 161.2e-3
rk2112 n108__vdd n270__vdd 882.9e-3
rk2113 n270__vdd n98__vdd 161.2e-3
rk2114 n98__vdd n271__vdd 882.7e-3
rk2115 n271__vdd n88__vdd 161.2e-3
rk2116 n88__vdd n272__vdd 882.9e-3
rk2117 n272__vdd n78__vdd 161.2e-3
rk2118 n78__vdd n273__vdd 882.9e-3
rk2119 n273__vdd n68__vdd 161.2e-3
rk2120 n68__vdd n274__vdd 882.9e-3
rk2121 n274__vdd n58__vdd 161.2e-3
rk2122 n58__vdd n275__vdd 882.9e-3
rk2123 n275__vdd n48__vdd 161.2e-3
rk2124 n48__vdd n276__vdd 882.9e-3
rk2125 n276__vdd n38__vdd 161.2e-3
rk2126 n38__vdd n277__vdd 882.7e-3
rk2127 n277__vdd n28__vdd 161.2e-3
rk2128 n28__vdd n278__vdd 882.9e-3
rk2129 n278__vdd n18__vdd 161.2e-3
rk2130 n18__vdd n4__vdd 522.4e-3
rk2131 n260__vdd n279__vdd 75.1025
rk2132 n262__vdd n280__vdd 75.1025
rk2133 n264__vdd n281__vdd 75.1025
rk2134 n266__vdd n282__vdd 75.1025
rk2135 n267__vdd n283__vdd 75.1025
rk2136 n268__vdd n284__vdd 75.1025
rk2137 n269__vdd n285__vdd 75.1025
rk2138 n270__vdd n286__vdd 75.1025
rk2139 n271__vdd n287__vdd 75.1025
rk2140 n272__vdd n288__vdd 75.1025
rk2141 n273__vdd n289__vdd 75.1025
rk2142 n274__vdd n290__vdd 75.1025
rk2143 n275__vdd n291__vdd 75.1025
rk2144 n276__vdd n292__vdd 75.1025
rk2145 n277__vdd n293__vdd 75.1025
rk2146 n278__vdd n294__vdd 75.1025
rk2147 n5__i29__net7 n6__i29__net7 2.601e-3
rk2148 n7__i29__net7 n8__i29__net7 2.601e-3
rk2149 n6__i29__net7 n7__i29__net7 15.28e-3
rk2150 n4__i29__net7 n5__i29__net7 31
rk2151 n4__i40__i43__x n5__i40__i43__x 20.9555
rk2152 n5__i40__i43__x n2__i40__i43__x 45.1172
rk2153 n5__i40__i43__x n6__i40__i43__x 75.2238
rk2154 n9__net37 n10__net37 6.895e-3
rk2155 n8__net37 n9__net37 75
rk2156 n559__clk1pt6g n605__clk1pt6g 4.773e-3
rk2157 n561__clk1pt6g n606__clk1pt6g 3.265e-3
rk2159 n169__net23 n148__net23 3.265e-3
rk2160 n608__clk1pt6g n558__clk1pt6g 3.674e-3
rk2161 n142__net29 n127__net29 3.265e-3
rk2162 n9__i29__net7 n11__i29__net7 48.49e-3
rk2163 n11__i29__net7 n12__i29__net7 75.5602
rk2164 n10__i29__net7 n11__i29__net7 31
rk2165 n231__clk100m_b n220__clk100m_b 1.1438
rk2166 n220__clk100m_b n206__clk100m_b 1.1438
rk2167 n206__clk100m_b n192__clk100m_b 1.1438
rk2168 n192__clk100m_b n176__clk100m_b 1.1438
rk2169 n176__clk100m_b n162__clk100m_b 1.1438
rk2170 n162__clk100m_b n148__clk100m_b 1.1438
rk2171 n148__clk100m_b n134__clk100m_b 1.1438
rk2172 n134__clk100m_b n96__clk100m_b 1.1438
rk2173 n96__clk100m_b n82__clk100m_b 1.1438
rk2174 n82__clk100m_b n68__clk100m_b 1.1438
rk2175 n68__clk100m_b n51__clk100m_b 1.1438
rk2176 n51__clk100m_b n37__clk100m_b 1.1438
rk2177 n37__clk100m_b n23__clk100m_b 1.1438
rk2178 n23__clk100m_b n15__clk100m_b 1.1438
rk2179 n15__clk100m_b n54__clk100m_b 1.159
rk2180 n6__net24 n10__net24 303.5e-3
rk2181 n10__net24 n11__net24 37.6789
rk2182 n10__net24 n12__net24 15.7761
rk2183 n2__i29__net8 n4__i29__net8 508.6e-3
rk2184 n4__i29__net8 n5__i29__net8 31.2567
rk2185 n4__i29__net8 n6__i29__net8 75.1255
rk2186 n5__out15 n6__out15 20.9587
rk2187 n6__out15 n1__out15 91.08e-3
rk2188 n6__out15 n7__out15 60.67e-3
rk2189 n7__out15 n8__out15 75.1321
rk2191 n610__clk1pt6g n568__clk1pt6g 3.014e-3
rk2193 n171__net23 n154__net23 3.265e-3
rk2194 n152__net23 n172__net23 557e-3
rk2195 n128__net29 n143__net29 3.674e-3
rk2196 n569__clk1pt6g n611__clk1pt6g 3.265e-3
rk2197 n3__i29__i161__x n5__i29__i161__x 85.19e-3
rk2198 n5__i29__i161__x n6__i29__i161__x 75.2385
rk2199 n5__i29__i161__x n7__i29__i161__x 31.3419
rk2200 n78__vss n79__vss 2.601e-3
rk2201 n80__vss n82__vss 2.601e-3
rk2202 n79__vss n80__vss 15.28e-3
rk2203 n81__vss n82__vss 31
rk2204 n83__vss n85__vss 2.601e-3
rk2205 n86__vss n87__vss 2.601e-3
rk2206 n83__vss n87__vss 15.28e-3
rk2207 n84__vss n85__vss 31
rk2208 net20 n3__net20 6.782e-3
rk2209 n2__net20 n3__net20 75
rk2210 n5__net20 n6__net20 6.895e-3
rk2211 n4__net20 n5__net20 75
rk2215 n4__i40__i42__x n5__i40__i42__x 20.9555
rk2216 n5__i40__i42__x n2__i40__i42__x 45.1172
rk2217 n5__i40__i42__x n6__i40__i42__x 75.2238
rk2218 n581__clk1pt6g n612__clk1pt6g 4.773e-3
rk2220 n614__clk1pt6g n583__clk1pt6g 3.265e-3
rk2221 n173__net23 n157__net23 3.265e-3
rk2222 net1 n2__net1 31.2678
rk2223 n2__net1 n3__net1 688.8e-3
rk2224 n3__net1 n4__net1 19.0261
rk2225 n2__net1 n5__net1 75.1255
rk2226 n3__net1 n6__net1 8.2204
rk2227 n5__net28 n6__net28 75.1255
rk2228 n6__net28 n7__net28 2.3753
rk2229 n6__net28 n8__net28 31.2678
rk2230 n615__clk1pt6g n580__clk1pt6g 3.265e-3
rk2231 n144__net29 n135__net29 3.265e-3
rk2232 n11__net21 n12__net21 31.2878
rk2233 n12__net21 n13__net21 75.251
rk2234 n7__net20 n9__net20 13.27e-3
rk2235 n8__net20 n9__net20 31
rk2237 n296__vdd n297__vdd 164.2e-3
rk2238 n297__vdd n298__vdd 647.8e-3
rk2239 n296__vdd n299__vdd 31.1291
rk2240 n297__vdd n300__vdd 75.1018
rk2241 n88__vss n89__vss 75.0913
rk2242 n89__vss n90__vss 2.9878
rk2243 n90__vss n91__vss 1.1297
rk2244 n91__vss n92__vss 1.1297
rk2245 n92__vss n93__vss 1.1297
rk2246 n93__vss n94__vss 1.1297
rk2247 n94__vss n95__vss 1.1297
rk2248 n95__vss n96__vss 1.1297
rk2249 n96__vss n97__vss 1.1297
rk2250 n97__vss n98__vss 1.1297
rk2251 n98__vss n99__vss 1.1297
rk2252 n99__vss n100__vss 1.1297
rk2253 n100__vss n101__vss 1.1297
rk2254 n101__vss n102__vss 1.1297
rk2255 n102__vss n103__vss 1.1297
rk2256 n103__vss n104__vss 1.1297
rk2257 n104__vss n24__vss 1.2912
rk2258 n24__vss n105__vss 249.1e-3
rk2259 n105__vss n106__vss 2.3983
rk2260 n106__vss n107__vss 176.3e-3
rk2261 n107__vss n108__vss 169.8e-3
rk2262 n108__vss n109__vss 547.2e-3
rk2263 n109__vss n110__vss 550e-3
rk2264 n110__vss n111__vss 547.2e-3
rk2265 n111__vss n112__vss 550e-3
rk2266 n112__vss n113__vss 547.2e-3
rk2267 n113__vss n114__vss 550e-3
rk2268 n114__vss n115__vss 547.2e-3
rk2269 n115__vss n116__vss 550e-3
rk2270 n116__vss n117__vss 547.2e-3
rk2271 n117__vss n118__vss 550e-3
rk2272 n118__vss n119__vss 547.2e-3
rk2273 n119__vss n120__vss 550e-3
rk2274 n120__vss n121__vss 547.2e-3
rk2275 n121__vss n122__vss 550e-3
rk2276 n122__vss n123__vss 547.2e-3
rk2277 n123__vss n124__vss 550e-3
rk2278 n124__vss n125__vss 547.2e-3
rk2279 n125__vss n126__vss 550e-3
rk2280 n126__vss n127__vss 547.2e-3
rk2281 n127__vss n128__vss 550e-3
rk2282 n128__vss n129__vss 547.2e-3
rk2283 n129__vss n130__vss 550e-3
rk2284 n130__vss n131__vss 547.2e-3
rk2285 n131__vss n132__vss 550e-3
rk2286 n132__vss n133__vss 547.2e-3
rk2287 n133__vss n134__vss 550e-3
rk2288 n134__vss n135__vss 547.2e-3
rk2289 n135__vss n136__vss 550e-3
rk2290 n136__vss n137__vss 547.2e-3
rk2291 n137__vss n138__vss 550e-3
rk2292 n138__vss n139__vss 547.2e-3
rk2293 n139__vss n140__vss 2.8072
rk2294 n140__vss n141__vss 1.1441
rk2295 n141__vss n142__vss 1.1441
rk2296 n142__vss n143__vss 1.1441
rk2297 n143__vss n144__vss 1.1441
rk2298 n144__vss n145__vss 1.1441
rk2299 n145__vss n146__vss 1.1441
rk2300 n146__vss n147__vss 1.1441
rk2301 n147__vss n148__vss 1.1441
rk2302 n148__vss n149__vss 1.1441
rk2303 n149__vss n150__vss 1.1441
rk2304 n150__vss n151__vss 1.1441
rk2305 n151__vss n152__vss 1.1441
rk2306 n152__vss n153__vss 1.1441
rk2307 n153__vss n154__vss 1.1441
rk2308 n154__vss n155__vss 1.0976
rk2309 n155__vss n156__vss 1.1924
rk2310 n156__vss n157__vss 299.4e-3
rk2311 n157__vss n158__vss 182.9e-3
rk2312 n158__vss n159__vss 182.9e-3
rk2313 n159__vss n160__vss 75.4148
rk2314 n89__vss n161__vss 525.2e-3
rk2315 n161__vss n162__vss 550e-3
rk2316 n162__vss n163__vss 537.1e-3
rk2317 n163__vss n164__vss 550e-3
rk2318 n164__vss n165__vss 537.1e-3
rk2319 n165__vss n166__vss 550e-3
rk2320 n166__vss n167__vss 537.1e-3
rk2321 n167__vss n168__vss 550e-3
rk2322 n168__vss n169__vss 537.1e-3
rk2323 n169__vss n170__vss 550e-3
rk2324 n170__vss n171__vss 537.1e-3
rk2325 n171__vss n172__vss 550e-3
rk2326 n172__vss n173__vss 537.1e-3
rk2327 n173__vss n174__vss 550e-3
rk2328 n174__vss n175__vss 537.1e-3
rk2329 n175__vss n176__vss 550e-3
rk2330 n176__vss n177__vss 537.1e-3
rk2331 n177__vss n178__vss 550e-3
rk2332 n178__vss n179__vss 537.1e-3
rk2333 n179__vss n180__vss 550e-3
rk2334 n180__vss n181__vss 537.1e-3
rk2335 n181__vss n182__vss 550e-3
rk2336 n182__vss n183__vss 537.1e-3
rk2337 n183__vss n184__vss 540.3e-3
rk2338 n184__vss n185__vss 537.1e-3
rk2339 n185__vss n186__vss 550e-3
rk2340 n186__vss n187__vss 537.1e-3
rk2341 n187__vss n188__vss 550e-3
rk2342 n188__vss n189__vss 537.1e-3
rk2343 n189__vss n190__vss 550e-3
rk2344 n190__vss n191__vss 537.1e-3
rk2346 n90__vss n11__vss 62.0732
rk2347 n91__vss n11__vss 62.0732
rk2348 n92__vss n11__vss 62.0732
rk2349 n93__vss n11__vss 62.0732
rk2350 n94__vss n11__vss 62.0732
rk2351 n95__vss n11__vss 62.0732
rk2352 n96__vss n11__vss 62.0732
rk2353 n97__vss n11__vss 62.0732
rk2354 n98__vss n11__vss 62.0732
rk2355 n99__vss n11__vss 62.0732
rk2356 n100__vss n11__vss 62.0732
rk2357 n101__vss n11__vss 62.0732
rk2358 n102__vss n11__vss 62.0732
rk2359 n103__vss n11__vss 62.0732
rk2360 n104__vss n11__vss 62.0732
rk2361 n105__vss n11__vss 62.0927
rk2362 n105__vss n193__vss 999.3e-3
rk2363 n193__vss n11__vss 62.0732
rk2364 n106__vss n194__vss 694.7e-3
rk2365 n194__vss n195__vss 182.9e-3
rk2366 n195__vss n196__vss 75.4148
rk2367 n107__vss n11__vss 62.1174
rk2368 n108__vss n197__vss 75.0913
rk2369 n109__vss n198__vss 75.0913
rk2370 n110__vss n199__vss 75.0935
rk2371 n111__vss n200__vss 75.0913
rk2372 n112__vss n201__vss 75.0935
rk2373 n113__vss n202__vss 75.0913
rk2374 n114__vss n203__vss 75.0935
rk2375 n115__vss n204__vss 75.0913
rk2376 n116__vss n205__vss 75.0935
rk2377 n117__vss n206__vss 75.0913
rk2378 n118__vss n207__vss 75.0935
rk2379 n119__vss n208__vss 75.0913
rk2380 n120__vss n209__vss 75.0935
rk2381 n121__vss n210__vss 75.0913
rk2382 n122__vss n211__vss 75.0935
rk2383 n123__vss n212__vss 75.0913
rk2384 n124__vss n213__vss 75.0935
rk2385 n125__vss n214__vss 75.0913
rk2386 n126__vss n215__vss 75.0935
rk2387 n127__vss n216__vss 75.0913
rk2388 n128__vss n217__vss 75.0935
rk2389 n129__vss n218__vss 75.0913
rk2390 n130__vss n219__vss 75.0935
rk2391 n131__vss n220__vss 75.0913
rk2392 n132__vss n221__vss 75.0935
rk2393 n133__vss n222__vss 75.0913
rk2394 n134__vss n223__vss 75.0935
rk2395 n135__vss n224__vss 75.0913
rk2396 n136__vss n225__vss 75.0935
rk2397 n137__vss n226__vss 75.0913
rk2398 n138__vss n227__vss 75.0935
rk2399 n139__vss n228__vss 75.0913
rk2400 n140__vss n11__vss 62.0732
rk2401 n141__vss n11__vss 62.0732
rk2402 n142__vss n11__vss 62.0732
rk2403 n143__vss n11__vss 62.0732
rk2404 n144__vss n11__vss 62.0732
rk2405 n145__vss n11__vss 62.0732
rk2406 n146__vss n11__vss 62.0732
rk2407 n147__vss n11__vss 62.0732
rk2408 n148__vss n11__vss 62.0732
rk2409 n149__vss n11__vss 62.0732
rk2410 n150__vss n11__vss 62.0732
rk2411 n151__vss n11__vss 62.0732
rk2412 n152__vss n11__vss 62.0732
rk2413 n153__vss n11__vss 62.0732
rk2414 n154__vss n11__vss 62.0732
rk2415 n155__vss n11__vss 62.0732
rk2416 n156__vss n229__vss 75.112
rk2417 n157__vss n230__vss 75.0859
rk2418 n158__vss n11__vss 62.0816
rk2419 n159__vss n231__vss 75.0859
rk2420 n161__vss n232__vss 75.0877
rk2421 n162__vss n233__vss 75.0913
rk2422 n163__vss n234__vss 75.0877
rk2423 n164__vss n235__vss 75.0913
rk2424 n165__vss n236__vss 75.0877
rk2425 n166__vss n237__vss 75.0913
rk2426 n167__vss n238__vss 75.0877
rk2427 n168__vss n239__vss 75.0913
rk2428 n169__vss n240__vss 75.0877
rk2429 n170__vss n241__vss 75.0913
rk2430 n171__vss n242__vss 75.0877
rk2431 n172__vss n243__vss 75.0913
rk2432 n173__vss n244__vss 75.0877
rk2433 n174__vss n245__vss 75.0913
rk2434 n175__vss n246__vss 75.0877
rk2435 n176__vss n247__vss 75.0913
rk2436 n177__vss n248__vss 75.0877
rk2437 n178__vss n249__vss 75.0913
rk2438 n179__vss n250__vss 75.0877
rk2439 n180__vss n251__vss 75.0913
rk2440 n181__vss n252__vss 75.0877
rk2441 n182__vss n253__vss 75.0913
rk2442 n183__vss n254__vss 75.0877
rk2443 n184__vss n255__vss 75.0913
rk2444 n185__vss n256__vss 75.0877
rk2445 n186__vss n257__vss 75.0913
rk2446 n187__vss n258__vss 75.0877
rk2447 n188__vss n259__vss 75.0913
rk2448 n189__vss n260__vss 75.0877
rk2449 n190__vss n261__vss 75.0913
rk2450 n191__vss n262__vss 75.0859
rk2451 n193__vss n263__vss 1.0203
rk2452 n263__vss n11__vss 62.0732
rk2453 n194__vss n11__vss 62.0816
rk2454 n195__vss n264__vss 75.0859
rk2455 n263__vss n265__vss 1.0203
rk2456 n265__vss n11__vss 62.0732
rk2457 n265__vss n266__vss 1.0203
rk2458 n266__vss n11__vss 62.0732
rk2459 n266__vss n267__vss 1.0203
rk2460 n267__vss n11__vss 62.0732
rk2461 n267__vss n268__vss 1.0203
rk2462 n268__vss n11__vss 62.0732
rk2463 n268__vss n269__vss 1.0203
rk2464 n269__vss n11__vss 62.0732
rk2465 n269__vss n270__vss 1.0203
rk2466 n270__vss n11__vss 62.0732
rk2467 n270__vss n271__vss 1.0203
rk2468 n271__vss n11__vss 62.0732
rk2469 n271__vss n272__vss 1.0203
rk2470 n272__vss n11__vss 62.0732
rk2471 n272__vss n273__vss 1.0203
rk2472 n273__vss n11__vss 62.0732
rk2473 n273__vss n274__vss 1.0203
rk2474 n274__vss n11__vss 62.0732
rk2475 n274__vss n275__vss 1.0203
rk2476 n275__vss n11__vss 62.0732
rk2477 n275__vss n276__vss 1.0203
rk2478 n276__vss n11__vss 62.0732
rk2479 n276__vss n277__vss 1.0203
rk2480 n277__vss n11__vss 62.0732
rk2482 n10__net20 n12__net20 679.8e-3
rk2483 n12__net20 n13__net20 513.3e-3
rk2484 n11__net20 n12__net20 31
rk2485 n9__net28 net28 689.7e-3
rk2487 n302__vdd n303__vdd 163.5e-3
rk2488 n303__vdd n304__vdd 500.9e-3
rk2489 n304__vdd n305__vdd 510.1e-3
rk2490 n305__vdd n306__vdd 500.9e-3
rk2491 n306__vdd n307__vdd 510.1e-3
rk2492 n307__vdd n308__vdd 500.9e-3
rk2493 n308__vdd n309__vdd 510.1e-3
rk2494 n309__vdd n310__vdd 500.9e-3
rk2495 n310__vdd n311__vdd 510.1e-3
rk2496 n311__vdd n312__vdd 500.9e-3
rk2497 n312__vdd n313__vdd 510.1e-3
rk2498 n313__vdd n314__vdd 500.9e-3
rk2499 n314__vdd n315__vdd 510.1e-3
rk2500 n315__vdd n316__vdd 500.9e-3
rk2501 n316__vdd n317__vdd 510.1e-3
rk2502 n317__vdd n318__vdd 500.9e-3
rk2503 n318__vdd n319__vdd 510.1e-3
rk2504 n319__vdd n320__vdd 500.9e-3
rk2505 n320__vdd n321__vdd 510.1e-3
rk2506 n321__vdd n322__vdd 500.9e-3
rk2507 n322__vdd n323__vdd 510.1e-3
rk2508 n323__vdd n324__vdd 500.9e-3
rk2509 n324__vdd n325__vdd 510.1e-3
rk2510 n325__vdd n326__vdd 500.9e-3
rk2511 n326__vdd n327__vdd 510.1e-3
rk2512 n327__vdd n328__vdd 500.9e-3
rk2513 n328__vdd n329__vdd 510.1e-3
rk2514 n329__vdd n330__vdd 500.9e-3
rk2515 n330__vdd n331__vdd 510.1e-3
rk2516 n331__vdd n332__vdd 500.9e-3
rk2517 n332__vdd n333__vdd 510.1e-3
rk2518 n333__vdd n334__vdd 500.9e-3
rk2519 n334__vdd n335__vdd 497.1e-3
rk2520 n335__vdd n336__vdd 396e-3
rk2521 n336__vdd n337__vdd 296.3e-3
rk2522 n337__vdd n338__vdd 296.3e-3
rk2523 n338__vdd n339__vdd 296.3e-3
rk2524 n339__vdd n340__vdd 440e-3
rk2525 n340__vdd n341__vdd 3.1721
rk2526 n341__vdd n342__vdd 12.9926
rk2527 n302__vdd n343__vdd 75.1154
rk2528 n303__vdd n344__vdd 20.8572
rk2529 n304__vdd n345__vdd 20.8552
rk2530 n305__vdd n346__vdd 20.8442
rk2531 n306__vdd n347__vdd 20.8552
rk2532 n307__vdd n348__vdd 20.8442
rk2533 n308__vdd n349__vdd 20.8552
rk2534 n309__vdd n350__vdd 20.8442
rk2535 n310__vdd n351__vdd 20.8552
rk2536 n311__vdd n352__vdd 20.8442
rk2537 n312__vdd n353__vdd 20.8552
rk2538 n313__vdd n354__vdd 20.8442
rk2539 n314__vdd n355__vdd 20.8552
rk2540 n315__vdd n356__vdd 20.8442
rk2541 n316__vdd n357__vdd 20.8552
rk2542 n317__vdd n358__vdd 20.8442
rk2543 n318__vdd n359__vdd 20.8552
rk2544 n319__vdd n360__vdd 20.8442
rk2545 n320__vdd n361__vdd 20.8552
rk2546 n321__vdd n362__vdd 20.8442
rk2547 n322__vdd n363__vdd 20.8552
rk2548 n323__vdd n364__vdd 20.8442
rk2549 n324__vdd n365__vdd 20.8552
rk2550 n325__vdd n366__vdd 20.8442
rk2551 n326__vdd n367__vdd 20.8552
rk2552 n327__vdd n368__vdd 20.8442
rk2553 n328__vdd n369__vdd 20.8552
rk2554 n329__vdd n370__vdd 20.8442
rk2555 n330__vdd n371__vdd 20.8552
rk2556 n331__vdd n372__vdd 20.8442
rk2557 n332__vdd n373__vdd 20.8552
rk2558 n333__vdd n374__vdd 20.8442
rk2559 n334__vdd n375__vdd 20.8552
rk2560 n335__vdd n343__vdd 75.1147
rk2561 n336__vdd n376__vdd 4.6592
rk2562 n337__vdd n377__vdd 4.6951
rk2563 n338__vdd n378__vdd 4.6951
rk2564 n339__vdd n379__vdd 4.6951
rk2565 n340__vdd n381__vdd 169.6e-3
rk2566 n381__vdd n383__vdd 13.48e-3
rk2568 n341__vdd n385__vdd 196.7e-3
rk2569 n385__vdd n386__vdd 8.1678
rk2570 n385__vdd n387__vdd 359.5e-3
rk2571 n387__vdd n388__vdd 8.1814
rk2572 n387__vdd n389__vdd 359.5e-3
rk2573 n389__vdd n390__vdd 8.1814
rk2574 n389__vdd n391__vdd 359.5e-3
rk2575 n391__vdd n392__vdd 8.1814
rk2576 n391__vdd n393__vdd 359.5e-3
rk2577 n393__vdd n394__vdd 8.1814
rk2578 n393__vdd n395__vdd 359.5e-3
rk2579 n395__vdd n396__vdd 8.1814
rk2580 n395__vdd n397__vdd 359.5e-3
rk2581 n397__vdd n398__vdd 8.1814
rk2582 n397__vdd n399__vdd 359.5e-3
rk2583 n399__vdd n400__vdd 8.1814
rk2584 n399__vdd n401__vdd 646.9e-3
rk2585 n401__vdd n402__vdd 7.8699
rk2586 n401__vdd n403__vdd 189.2e-3
rk2587 n403__vdd n342__vdd 75.2566
rk2588 n403__vdd n404__vdd 1.4696
rk2589 n404__vdd n405__vdd 128.9e-3
rk2590 n405__vdd n406__vdd 153.6e-3
rk2591 n406__vdd n407__vdd 8.1447
rk2592 n403__vdd vdd 102.7e-3
rk2593 vdd n408__vdd 86.6e-3
rk2594 n408__vdd n409__vdd 15.777
rk2595 n404__vdd n410__vdd 286.4e-3
rk2596 n410__vdd n411__vdd 12.9404
rk2597 n405__vdd n412__vdd 843.6e-3
rk2598 n412__vdd n17__vdd 505e-3
rk2599 n406__vdd n413__vdd 296.3e-3
rk2600 n413__vdd n414__vdd 8.1814
rk2601 n408__vdd n415__vdd 290.9e-3
rk2602 n415__vdd n416__vdd 15.7986
rk2603 n410__vdd n417__vdd 170e-3
rk2604 n417__vdd n418__vdd 8.1678
rk2605 n412__vdd n419__vdd 348.1e-3
rk2606 n419__vdd n420__vdd 31.1297
rk2607 n413__vdd n421__vdd 296.3e-3
rk2608 n421__vdd n422__vdd 8.1814
rk2609 n415__vdd n423__vdd 578e-3
rk2610 n423__vdd n424__vdd 15.7986
rk2611 n417__vdd n425__vdd 296.3e-3
rk2612 n425__vdd n426__vdd 8.1814
rk2613 n419__vdd n427__vdd 493.4e-3
rk2614 n427__vdd n428__vdd 31.1399
rk2615 n421__vdd n429__vdd 296.3e-3
rk2616 n429__vdd n430__vdd 8.1814
rk2617 n423__vdd n431__vdd 290.9e-3
rk2618 n431__vdd n432__vdd 15.7986
rk2619 n425__vdd n433__vdd 296.3e-3
rk2620 n433__vdd n434__vdd 8.1814
rk2621 n427__vdd n435__vdd 289.8e-3
rk2622 n435__vdd n436__vdd 75.1514
rk2623 n429__vdd n437__vdd 296.3e-3
rk2624 n437__vdd n438__vdd 8.1814
rk2625 n431__vdd n439__vdd 777.4e-3
rk2626 n439__vdd n440__vdd 72.49e-3
rk2627 n440__vdd n441__vdd 15.9453
rk2628 n433__vdd n442__vdd 296.3e-3
rk2629 n442__vdd n443__vdd 8.1814
rk2630 n435__vdd n444__vdd 204e-3
rk2631 n444__vdd n445__vdd 31.1399
rk2632 n437__vdd n446__vdd 296.3e-3
rk2633 n446__vdd n447__vdd 8.1814
rk2634 n439__vdd n448__vdd 501.1e-3
rk2635 n448__vdd n449__vdd 72.49e-3
rk2636 n449__vdd n450__vdd 15.9746
rk2637 n440__vdd n451__vdd 15.8811
rk2638 n442__vdd n452__vdd 296.3e-3
rk2639 n452__vdd n453__vdd 8.1814
rk2640 n444__vdd n454__vdd 493.4e-3
rk2641 n454__vdd n455__vdd 31.1399
rk2642 n446__vdd n456__vdd 296.3e-3
rk2643 n456__vdd n457__vdd 8.1814
rk2644 n448__vdd n458__vdd 325.1e-3
rk2645 n458__vdd n459__vdd 15.777
rk2646 n449__vdd n460__vdd 15.83
rk2647 n452__vdd n461__vdd 296.3e-3
rk2648 n461__vdd n462__vdd 8.1814
rk2649 n454__vdd n463__vdd 289.8e-3
rk2650 n463__vdd n436__vdd 75.1514
rk2651 n456__vdd n464__vdd 296.3e-3
rk2652 n464__vdd n465__vdd 8.1814
rk2653 n458__vdd n466__vdd 290.9e-3
rk2654 n466__vdd n467__vdd 15.7986
rk2655 n461__vdd n468__vdd 296.3e-3
rk2656 n468__vdd n469__vdd 8.1814
rk2657 n463__vdd n470__vdd 204e-3
rk2658 n470__vdd n471__vdd 31.1399
rk2659 n464__vdd n472__vdd 296.3e-3
rk2660 n472__vdd n473__vdd 8.1678
rk2661 n466__vdd n474__vdd 589.5e-3
rk2662 n474__vdd n475__vdd 15.7986
rk2663 n468__vdd n476__vdd 296.3e-3
rk2664 n476__vdd n477__vdd 8.1814
rk2665 n470__vdd n478__vdd 493.4e-3
rk2666 n478__vdd n479__vdd 31.1399
rk2667 n472__vdd n480__vdd 13.1158
rk2668 n474__vdd n481__vdd 290.9e-3
rk2669 n481__vdd n482__vdd 15.7986
rk2670 n476__vdd n483__vdd 296.3e-3
rk2671 n483__vdd n484__vdd 8.1857
rk2672 n478__vdd n485__vdd 289.8e-3
rk2673 n485__vdd n436__vdd 75.1514
rk2674 n481__vdd n486__vdd 788.9e-3
rk2675 n486__vdd n487__vdd 72.49e-3
rk2676 n487__vdd n488__vdd 15.9453
rk2677 n483__vdd n489__vdd 160.2e-3
rk2678 n489__vdd n490__vdd 8.1857
rk2679 n485__vdd n491__vdd 204e-3
rk2680 n491__vdd n492__vdd 31.1399
rk2681 n486__vdd n493__vdd 501.1e-3
rk2682 n493__vdd n494__vdd 72.49e-3
rk2683 n494__vdd n495__vdd 15.9746
rk2684 n487__vdd n496__vdd 15.8811
rk2685 n489__vdd n497__vdd 296.3e-3
rk2686 n497__vdd n498__vdd 8.1814
rk2687 n491__vdd n499__vdd 493.4e-3
rk2688 n499__vdd n500__vdd 31.1399
rk2689 n493__vdd n501__vdd 325.1e-3
rk2690 n501__vdd n502__vdd 15.777
rk2691 n494__vdd n503__vdd 15.83
rk2692 n497__vdd n504__vdd 296.3e-3
rk2693 n504__vdd n505__vdd 8.1814
rk2694 n499__vdd n506__vdd 289.8e-3
rk2695 n506__vdd n436__vdd 75.1514
rk2696 n501__vdd n507__vdd 290.9e-3
rk2697 n507__vdd n508__vdd 15.7986
rk2698 n504__vdd n509__vdd 296.3e-3
rk2699 n509__vdd n510__vdd 8.1814
rk2700 n506__vdd n511__vdd 199.1e-3
rk2701 n511__vdd n512__vdd 31.1399
rk2702 n507__vdd n513__vdd 589.5e-3
rk2703 n513__vdd n514__vdd 15.7986
rk2704 n509__vdd n515__vdd 296.3e-3
rk2705 n515__vdd n516__vdd 8.1814
rk2706 n511__vdd n517__vdd 493.4e-3
rk2707 n517__vdd n518__vdd 31.1399
rk2708 n513__vdd n519__vdd 290.9e-3
rk2709 n519__vdd n520__vdd 15.7986
rk2710 n515__vdd n521__vdd 296.3e-3
rk2711 n521__vdd n522__vdd 8.1814
rk2712 n517__vdd n523__vdd 289.8e-3
rk2713 n523__vdd n436__vdd 75.1514
rk2714 n519__vdd n524__vdd 789e-3
rk2715 n524__vdd n525__vdd 72.49e-3
rk2716 n525__vdd n526__vdd 15.9453
rk2717 n521__vdd n527__vdd 296.3e-3
rk2718 n527__vdd n528__vdd 8.1814
rk2719 n523__vdd n529__vdd 204e-3
rk2720 n529__vdd n530__vdd 31.1399
rk2721 n524__vdd n531__vdd 501.1e-3
rk2722 n531__vdd n532__vdd 72.49e-3
rk2723 n532__vdd n533__vdd 15.9746
rk2724 n525__vdd n534__vdd 15.8811
rk2725 n527__vdd n535__vdd 296.3e-3
rk2726 n535__vdd n536__vdd 8.1814
rk2727 n529__vdd n537__vdd 493.4e-3
rk2728 n537__vdd n538__vdd 31.1399
rk2729 n531__vdd n539__vdd 328.3e-3
rk2730 n539__vdd n540__vdd 15.777
rk2731 n532__vdd n541__vdd 15.83
rk2732 n535__vdd n542__vdd 296.3e-3
rk2733 n542__vdd n543__vdd 8.1857
rk2734 n537__vdd n544__vdd 289.8e-3
rk2735 n544__vdd n436__vdd 75.1514
rk2736 n539__vdd n545__vdd 290.9e-3
rk2737 n545__vdd n546__vdd 15.7986
rk2738 n542__vdd n547__vdd 163.5e-3
rk2739 n547__vdd n548__vdd 8.1857
rk2740 n544__vdd n549__vdd 204e-3
rk2741 n549__vdd n550__vdd 31.1399
rk2742 n545__vdd n551__vdd 590.4e-3
rk2743 n551__vdd n552__vdd 15.7986
rk2744 n547__vdd n553__vdd 296.3e-3
rk2745 n553__vdd n554__vdd 8.1814
rk2746 n549__vdd n555__vdd 493.4e-3
rk2747 n555__vdd n556__vdd 31.1399
rk2748 n551__vdd n557__vdd 290.9e-3
rk2749 n557__vdd n558__vdd 15.7986
rk2750 n553__vdd n559__vdd 296.3e-3
rk2751 n559__vdd n560__vdd 8.1814
rk2752 n555__vdd n561__vdd 289.8e-3
rk2753 n561__vdd n436__vdd 75.1514
rk2754 n557__vdd n562__vdd 789.6e-3
rk2755 n562__vdd n563__vdd 72.49e-3
rk2756 n563__vdd n564__vdd 15.9453
rk2757 n559__vdd n565__vdd 296.3e-3
rk2758 n565__vdd n566__vdd 8.1814
rk2759 n561__vdd n567__vdd 204e-3
rk2760 n567__vdd n568__vdd 31.1399
rk2761 n562__vdd n569__vdd 500.4e-3
rk2762 n569__vdd n570__vdd 72.49e-3
rk2763 n570__vdd n571__vdd 15.9746
rk2764 n563__vdd n572__vdd 15.8811
rk2765 n565__vdd n573__vdd 296.3e-3
rk2766 n573__vdd n574__vdd 8.1857
rk2767 n567__vdd n575__vdd 493.4e-3
rk2768 n575__vdd n576__vdd 31.1399
rk2769 n569__vdd n577__vdd 328.3e-3
rk2770 n577__vdd n578__vdd 15.777
rk2771 n570__vdd n579__vdd 15.83
rk2772 n573__vdd n580__vdd 163.5e-3
rk2773 n580__vdd n581__vdd 8.1857
rk2774 n575__vdd n582__vdd 289.8e-3
rk2775 n582__vdd n436__vdd 75.1514
rk2776 n577__vdd n583__vdd 290.9e-3
rk2777 n583__vdd n584__vdd 15.7986
rk2778 n580__vdd n585__vdd 296.3e-3
rk2779 n585__vdd n586__vdd 8.1857
rk2780 n582__vdd n587__vdd 204e-3
rk2781 n587__vdd n588__vdd 31.1399
rk2782 n583__vdd n589__vdd 589.5e-3
rk2783 n589__vdd n590__vdd 15.7986
rk2784 n585__vdd n591__vdd 505e-3
rk2785 n591__vdd n592__vdd 15.7675
rk2786 n587__vdd n593__vdd 493.4e-3
rk2787 n593__vdd n594__vdd 31.1399
rk2788 n589__vdd n595__vdd 290.9e-3
rk2789 n595__vdd n596__vdd 15.7986
rk2790 n591__vdd n597__vdd 15.9891
rk2791 n593__vdd n598__vdd 289.8e-3
rk2792 n598__vdd n436__vdd 75.1514
rk2793 n595__vdd n599__vdd 778.8e-3
rk2794 n599__vdd n600__vdd 73.64e-3
rk2795 n600__vdd n601__vdd 15.9453
rk2796 n598__vdd n602__vdd 204e-3
rk2797 n602__vdd n603__vdd 31.1399
rk2798 n599__vdd n604__vdd 620.4e-3
rk2799 n600__vdd n605__vdd 15.8552
rk2800 n602__vdd n606__vdd 493.4e-3
rk2801 n606__vdd n607__vdd 31.1399
rk2802 n606__vdd n608__vdd 289.8e-3
rk2803 n608__vdd n436__vdd 75.1514
rk2804 n608__vdd n609__vdd 204e-3
rk2805 n609__vdd n610__vdd 31.1399
rk2806 n609__vdd n611__vdd 493.4e-3
rk2807 n611__vdd n612__vdd 31.1399
rk2808 n611__vdd n613__vdd 289.8e-3
rk2809 n613__vdd n436__vdd 75.1514
rk2810 n613__vdd n614__vdd 204e-3
rk2811 n614__vdd n615__vdd 31.1399
rk2812 n614__vdd n616__vdd 493.4e-3
rk2813 n616__vdd n617__vdd 31.1399
rk2814 n616__vdd n618__vdd 289.8e-3
rk2815 n618__vdd n436__vdd 75.1514
rk2816 n618__vdd n619__vdd 204e-3
rk2817 n619__vdd n620__vdd 31.1399
rk2818 n619__vdd n621__vdd 493.4e-3
rk2819 n621__vdd n622__vdd 31.1399
rk2820 n621__vdd n623__vdd 289.8e-3
rk2821 n623__vdd n436__vdd 75.1514
rk2822 n623__vdd n624__vdd 204e-3
rk2823 n624__vdd n625__vdd 31.1399
rk2824 n624__vdd n626__vdd 493.4e-3
rk2825 n626__vdd n627__vdd 31.1399
rk2826 n626__vdd n628__vdd 289.8e-3
rk2827 n628__vdd n436__vdd 75.1514
rk2828 n628__vdd n629__vdd 204e-3
rk2829 n629__vdd n630__vdd 31.1399
rk2830 n629__vdd n631__vdd 493.4e-3
rk2831 n631__vdd n632__vdd 31.1399
rk2832 n631__vdd n633__vdd 289.8e-3
rk2833 n633__vdd n436__vdd 75.1514
rk2834 n633__vdd n634__vdd 204e-3
rk2835 n634__vdd n635__vdd 31.1399
rk2836 n634__vdd n636__vdd 456.6e-3
rk2837 n636__vdd n637__vdd 31.1399
rk2839 n380__vdd n381__vdd 6.8182
rk2840 n382__vdd n383__vdd 3.875
rk2841 n8__net25 n9__net25 1.5293
rk2842 n9__net25 n10__net25 75.1541
rk2843 n9__net25 n11__net25 31.139
rk2845 n640__vdd n642__vdd 198.4e-3
rk2846 n640__vdd n411__vdd 75.101
rk2847 n642__vdd n643__vdd 712e-3
rk2848 n643__vdd n644__vdd 8.1536
rk2849 n643__vdd n645__vdd 500.5e-3
rk2850 n645__vdd n646__vdd 15.7499
rk2851 n645__vdd n647__vdd 270.2e-3
rk2852 n647__vdd n648__vdd 15.7155
rk2853 n647__vdd n649__vdd 306e-3
rk2854 n649__vdd n650__vdd 234.3e-3
rk2855 n650__vdd n411__vdd 75.0024
rk2856 n649__vdd n651__vdd 195.9e-3
rk2857 n651__vdd n652__vdd 15.7804
rk2858 n651__vdd n653__vdd 290.9e-3
rk2859 n653__vdd n654__vdd 15.7986
rk2860 n653__vdd n655__vdd 571.6e-3
rk2861 n655__vdd n656__vdd 15.7986
rk2862 n655__vdd n657__vdd 290.9e-3
rk2863 n657__vdd n658__vdd 15.7986
rk2864 n657__vdd n659__vdd 582.6e-3
rk2865 n659__vdd n660__vdd 15.7986
rk2866 n659__vdd n661__vdd 290.9e-3
rk2867 n661__vdd n662__vdd 15.7986
rk2868 n661__vdd n663__vdd 571.6e-3
rk2869 n663__vdd n664__vdd 15.7986
rk2870 n663__vdd n665__vdd 290.9e-3
rk2871 n665__vdd n666__vdd 15.7986
rk2872 n665__vdd n667__vdd 565e-3
rk2873 n667__vdd n668__vdd 7.8915
rk2874 n667__vdd n669__vdd 567.3e-3
rk2875 n669__vdd n670__vdd 8.1857
rk2876 n669__vdd n671__vdd 163.5e-3
rk2877 n671__vdd n672__vdd 8.1857
rk2878 n671__vdd n673__vdd 8.4811
rk2879 n641__vdd n642__vdd 7.75
rk2880 n11__vss n279__vss 62.0758
rk2881 n279__vss n280__vss 1.8704
rk2882 n280__vss n281__vss 942.9e-3
rk2883 n281__vss n282__vss 1.2031
rk2884 n282__vss n283__vss 192.5e-3
rk2885 n283__vss n284__vss 228.1e-3
rk2886 n284__vss n285__vss 336.1e-3
rk2887 n285__vss n286__vss 471.6e-3
rk2888 n286__vss n288__vss 124e-3
rk2889 n279__vss n289__vss 163.5e-3
rk2890 n289__vss n290__vss 526.9e-3
rk2891 n290__vss n291__vss 539.3e-3
rk2892 n291__vss n292__vss 526.9e-3
rk2893 n292__vss n293__vss 539.3e-3
rk2894 n293__vss n294__vss 526.9e-3
rk2895 n294__vss n295__vss 539.3e-3
rk2896 n295__vss n296__vss 526.9e-3
rk2897 n296__vss n297__vss 539.3e-3
rk2898 n297__vss n298__vss 526.9e-3
rk2899 n298__vss n299__vss 539.3e-3
rk2900 n299__vss n300__vss 526.9e-3
rk2901 n300__vss n301__vss 539.3e-3
rk2902 n301__vss n302__vss 526.9e-3
rk2903 n302__vss n303__vss 539.3e-3
rk2904 n303__vss n304__vss 526.9e-3
rk2905 n304__vss n305__vss 539.3e-3
rk2906 n305__vss n306__vss 526.9e-3
rk2907 n306__vss n307__vss 539.3e-3
rk2908 n307__vss n308__vss 526.9e-3
rk2909 n308__vss n309__vss 539.3e-3
rk2910 n309__vss n310__vss 526.9e-3
rk2911 n310__vss n311__vss 539.3e-3
rk2912 n311__vss n312__vss 526.9e-3
rk2913 n312__vss n313__vss 539.3e-3
rk2914 n313__vss n314__vss 526.9e-3
rk2915 n314__vss n315__vss 539.3e-3
rk2916 n315__vss n316__vss 526.9e-3
rk2917 n316__vss n317__vss 539.3e-3
rk2918 n317__vss n318__vss 526.9e-3
rk2919 n318__vss n319__vss 539.3e-3
rk2920 n319__vss n320__vss 526.9e-3
rk2921 n320__vss n321__vss 536.1e-3
rk2922 n321__vss n322__vss 1.868
rk2923 n322__vss n323__vss 296.3e-3
rk2924 n323__vss n324__vss 296.3e-3
rk2925 n324__vss n325__vss 296.3e-3
rk2926 n325__vss n326__vss 502.9e-3
rk2927 n326__vss n327__vss 9.3815
rk2928 n280__vss n328__vss 75.4611
rk2929 n281__vss n329__vss 503.3e-3
rk2930 n329__vss n330__vss 856.7e-3
rk2931 n330__vss n331__vss 315.1e-3
rk2932 n331__vss n332__vss 631.2e-3
rk2933 n332__vss n333__vss 305.6e-3
rk2934 n333__vss n334__vss 351.8e-3
rk2935 n334__vss n335__vss 531.1e-3
rk2936 n335__vss n336__vss 856.7e-3
rk2937 n336__vss n337__vss 313.3e-3
rk2938 n337__vss n338__vss 632.8e-3
rk2939 n338__vss n339__vss 303.9e-3
rk2940 n339__vss n340__vss 353.4e-3
rk2941 n340__vss n341__vss 533.2e-3
rk2942 n341__vss n342__vss 856.7e-3
rk2943 n342__vss n343__vss 311.7e-3
rk2944 n343__vss n344__vss 634.2e-3
rk2945 n344__vss n345__vss 302.3e-3
rk2946 n345__vss n346__vss 351.8e-3
rk2947 n346__vss n347__vss 536.2e-3
rk2948 n347__vss n348__vss 856.7e-3
rk2949 n348__vss n349__vss 309.2e-3
rk2950 n349__vss n350__vss 636.6e-3
rk2951 n350__vss n351__vss 299.9e-3
rk2952 n351__vss n352__vss 354.2e-3
rk2953 n352__vss n353__vss 537.3e-3
rk2954 n353__vss n354__vss 856e-3
rk2955 n354__vss n355__vss 306.8e-3
rk2956 n355__vss n356__vss 639.7e-3
rk2957 n356__vss n357__vss 296.6e-3
rk2958 n357__vss n358__vss 196.5e-3
rk2959 n358__vss vss 92.06e-3
rk2960 vss n359__vss 130.3e-3
rk2961 n359__vss n360__vss 296.3e-3
rk2962 n360__vss n361__vss 296.3e-3
rk2963 n361__vss n362__vss 296.3e-3
rk2964 n362__vss n363__vss 296.3e-3
rk2965 n363__vss n364__vss 296.3e-3
rk2966 n364__vss n365__vss 296.3e-3
rk2967 n365__vss n366__vss 296.3e-3
rk2968 n366__vss n367__vss 296.3e-3
rk2969 n367__vss n11__vss 21.102
rk2970 n282__vss n368__vss 322.1e-3
rk2971 n368__vss n369__vss 195.9e-3
rk2972 n369__vss n370__vss 296.6e-3
rk2973 n370__vss n371__vss 568.7e-3
rk2974 n371__vss n372__vss 296.3e-3
rk2975 n372__vss n373__vss 581.7e-3
rk2976 n373__vss n374__vss 296.6e-3
rk2977 n374__vss n375__vss 568.7e-3
rk2978 n375__vss n376__vss 270.2e-3
rk2979 n376__vss n377__vss 632.1e-3
rk2980 n377__vss n378__vss 299.5e-3
rk2981 n378__vss n379__vss 163.5e-3
rk2982 n379__vss n380__vss 19.3067
rk2983 n283__vss n381__vss 37.6981
rk2984 n284__vss n382__vss 37.6601
rk2985 n285__vss n383__vss 18.9739
rk2986 n286__vss n384__vss 203.8e-3
rk2987 n384__vss n11__vss 62.0732
rk2988 n288__vss n386__vss 1.2378
rk2989 n386__vss n387__vss 504.8e-3
rk2990 n289__vss n388__vss 75.1199
rk2991 n290__vss n389__vss 75.1156
rk2992 n291__vss n390__vss 75.1101
rk2993 n292__vss n391__vss 75.1156
rk2994 n293__vss n392__vss 75.1101
rk2995 n294__vss n393__vss 75.1156
rk2996 n295__vss n394__vss 75.1101
rk2997 n296__vss n395__vss 75.1156
rk2998 n297__vss n396__vss 75.1101
rk2999 n298__vss n397__vss 75.1156
rk3000 n299__vss n398__vss 75.1101
rk3001 n300__vss n399__vss 75.1156
rk3002 n301__vss n400__vss 75.1101
rk3003 n302__vss n401__vss 75.1156
rk3004 n303__vss n402__vss 75.1101
rk3005 n304__vss n403__vss 75.1156
rk3006 n305__vss n404__vss 75.1101
rk3007 n306__vss n405__vss 75.1156
rk3008 n307__vss n406__vss 75.1101
rk3009 n308__vss n407__vss 75.1156
rk3010 n309__vss n408__vss 75.1101
rk3011 n310__vss n409__vss 75.1156
rk3012 n311__vss n410__vss 75.1101
rk3013 n312__vss n411__vss 75.1156
rk3014 n313__vss n412__vss 75.1101
rk3015 n314__vss n413__vss 75.1156
rk3016 n315__vss n414__vss 75.1101
rk3017 n316__vss n415__vss 75.1156
rk3018 n317__vss n416__vss 75.1101
rk3019 n318__vss n417__vss 75.1156
rk3020 n319__vss n418__vss 75.1101
rk3021 n320__vss n419__vss 75.1156
rk3022 n321__vss n11__vss 62.07
rk3023 n322__vss n420__vss 9.7632
rk3024 n323__vss n421__vss 9.8064
rk3025 n324__vss n422__vss 9.8064
rk3026 n325__vss n423__vss 9.8064
rk3027 n329__vss n424__vss 62.77e-3
rk3028 n424__vss n425__vss 37.8481
rk3029 n330__vss n426__vss 37.6788
rk3030 n331__vss n427__vss 37.6788
rk3031 n332__vss n428__vss 37.6788
rk3032 n333__vss n429__vss 37.668
rk3033 n334__vss n430__vss 62.77e-3
rk3034 n430__vss n431__vss 37.8775
rk3035 n335__vss n432__vss 62.77e-3
rk3036 n432__vss n433__vss 37.8481
rk3037 n336__vss n434__vss 37.6788
rk3038 n337__vss n435__vss 37.6788
rk3039 n338__vss n436__vss 37.6788
rk3040 n339__vss n437__vss 37.668
rk3041 n340__vss n438__vss 62.77e-3
rk3042 n438__vss n439__vss 37.8775
rk3043 n341__vss n440__vss 62.77e-3
rk3044 n440__vss n441__vss 37.8481
rk3045 n342__vss n442__vss 37.6788
rk3046 n343__vss n443__vss 37.6788
rk3047 n344__vss n444__vss 37.6788
rk3048 n345__vss n445__vss 37.668
rk3049 n346__vss n446__vss 62.77e-3
rk3050 n446__vss n447__vss 37.8775
rk3051 n347__vss n448__vss 62.77e-3
rk3052 n448__vss n449__vss 37.8481
rk3053 n348__vss n450__vss 37.6788
rk3054 n349__vss n451__vss 37.6788
rk3055 n350__vss n452__vss 37.6788
rk3056 n351__vss n453__vss 37.668
rk3057 n352__vss n454__vss 62.77e-3
rk3058 n454__vss n455__vss 37.8775
rk3059 n353__vss n456__vss 62.77e-3
rk3060 n456__vss n457__vss 37.8481
rk3061 n354__vss n458__vss 37.6788
rk3062 n355__vss n459__vss 37.6788
rk3063 n356__vss n460__vss 37.6788
rk3064 n357__vss n461__vss 37.668
rk3065 n358__vss n23__vss 150.9e-3
rk3066 n23__vss n11__vss 62
rk3067 n359__vss n462__vss 18.9655
rk3068 n360__vss n463__vss 18.9871
rk3069 n361__vss n464__vss 18.9871
rk3070 n362__vss n465__vss 18.9871
rk3071 n363__vss n466__vss 18.9871
rk3072 n364__vss n467__vss 18.9871
rk3073 n365__vss n468__vss 18.9871
rk3074 n366__vss n469__vss 18.9871
rk3075 n367__vss n470__vss 18.9816
rk3076 n368__vss n11__vss 62.1529
rk3077 n369__vss n471__vss 37.668
rk3078 n370__vss n472__vss 37.6788
rk3079 n371__vss n473__vss 37.6788
rk3080 n372__vss n474__vss 37.6788
rk3081 n373__vss n475__vss 37.6791
rk3082 n374__vss n476__vss 37.6788
rk3083 n375__vss n477__vss 37.6788
rk3084 n376__vss n478__vss 37.7048
rk3085 n377__vss n479__vss 18.9754
rk3086 n378__vss n480__vss 18.9914
rk3087 n379__vss n481__vss 18.9914
rk3088 n384__vss n483__vss 962e-3
rk3089 n483__vss n484__vss 504.8e-3
rk3090 n424__vss n485__vss 37.7689
rk3091 n430__vss n486__vss 37.7437
rk3092 n432__vss n487__vss 37.784
rk3093 n438__vss n488__vss 37.7437
rk3094 n440__vss n489__vss 37.784
rk3095 n446__vss n490__vss 37.7437
rk3096 n448__vss n491__vss 37.784
rk3097 n454__vss n492__vss 37.7437
rk3098 n456__vss n493__vss 37.784
rk3099 n287__vss n288__vss 18.75
rk3100 n11__vss n326__vss 8.8571
rk3101 n385__vss n386__vss 75
rk3102 n482__vss n483__vss 75
rl2 n2__i33__i58__net1 n3__i33__i58__net1 49.3144
rl3 n2__i33__i58__net1 n4__i33__i58__net1 34.3295
rl4 net5 n2__net5 79.0806
rl5 n5__i33__i58__net1 i33__i58__net1 77.5981
rl6 n3__net5 n4__net5 50.1171
rl7 n4__net5 n5__net5 34.3295
rl9 net17 n2__net17 79.0806
rl10 i33__i57__net1 n2__i33__i57__net1 34.3295
rl11 n2__i33__i57__net1 n3__i33__i57__net1 49.3144
rl13 n7__net5 n8__net5 81.9242
rl14 n7__net5 n9__net5 100
rl15 n5__i33__i57__net1 n6__i33__i57__net1 77.5981
rl16 n3__net17 n4__net17 50.1171
rl18 n4__net17 n6__net17 34.3295
rl19 net14 n2__net14 50.1171
rl20 n2__net14 n3__net14 43.9449
rl21 n2__net14 n4__net14 47.791
rl22 n7__net17 n8__net17 100
rl23 n8__net17 n9__net17 81.9242
rl24 i33__xor1 n2__i33__xor1 47.791
rl25 n2__i33__xor1 n3__i33__xor1 50.1123
rl26 n2__i33__xor1 n4__i33__xor1 43.9449
rl27 net16 n2__net16 50.1171
rl28 n2__net16 n3__net16 47.791
rl29 n2__net16 n4__net16 43.9449
rl30 i33__xor2 n2__i33__xor2 84.2177
rl31 n2__i33__xor2 n3__i33__xor2 100
rl33 n5__i33__xor2 n6__i33__xor2 50.1123
rl34 n5__i33__xor2 n7__i33__xor2 34.3295
rl35 i33__i56__net1 n2__i33__i56__net1 76.7349
rl36 n3__i33__i56__net1 n4__i33__i56__net1 49.3192
rl37 n4__i33__i56__net1 n5__i33__i56__net1 34.3295
rl39 n8__i33__xor2 n9__i33__xor2 79.9438
rl40 i33__i27__net1 n2__i33__i27__net1 72.3097
rl41 n2__i33__i27__net1 n3__i33__i27__net1 72.3097
rl42 clk100m n2__clk100m 71.1559
rl43 clk100m_b n2__clk100m_b 69.2328
rl44 n2__clk100m_b n3__clk100m_b 111.54
rl45 n1__rst n2__rst 38.1757
rl46 n2__rst n3__rst 49.3144
rl47 n2__rst n4__rst 80.4834
rl48 n4__rst n5__rst 111.54
rl49 n1__rst_b n2__rst_b 126.923
rl50 n2__rst_b n3__rst_b 69.2328
rl51 i33__i27__x n2__i33__i27__x 99.7141
rl52 n2__i33__i27__x n3__i33__i27__x 50.1123
rl53 n2__i33__i27__x n4__i33__i27__x 65.0987
rl54 n4__clk100m_b n5__clk100m_b 71.1559
rl55 n3__clk100m n4__clk100m 69.2328
rl56 n4__clk100m n5__clk100m 111.54
rl57 en_b n1__en_b 101.733
rl58 en_b n2__en_b 101.731
rl59 n2__en_b n3__en_b 126.923
rl60 i33__i28__net1 n2__i33__i28__net1 72.3097
rl61 n2__i33__i28__net1 n3__i33__i28__net1 72.3097
rl62 en n1__en 102.694
rl63 en n2__en 54.6154
rl64 n2__en n3__en 126.923
rl65 n1__clk1pt6g n2__clk1pt6g 42.1154
rl66 n2__clk1pt6g n3__clk1pt6g 40.1923
rl67 n3__clk1pt6g n4__clk1pt6g 106.321
rl68 n4__clk1pt6g n5__clk1pt6g 76.5385
rl69 n5__clk1pt6g n6__clk1pt6g 76.5385
rl70 n6__clk1pt6g n7__clk1pt6g 76.5385
rl71 n7__clk1pt6g n8__clk1pt6g 76.5385
rl72 n8__clk1pt6g n9__clk1pt6g 76.5385
rl73 n9__clk1pt6g n10__clk1pt6g 76.5385
rl74 n10__clk1pt6g n11__clk1pt6g 76.5385
rl75 n11__clk1pt6g n12__clk1pt6g 76.5385
rl76 n12__clk1pt6g n13__clk1pt6g 76.5385
rl77 n13__clk1pt6g n14__clk1pt6g 76.5385
rl78 n14__clk1pt6g n15__clk1pt6g 76.5385
rl79 n15__clk1pt6g n16__clk1pt6g 76.5385
rl80 n16__clk1pt6g n17__clk1pt6g 76.5385
rl81 n17__clk1pt6g n18__clk1pt6g 106.321
rl82 n18__clk1pt6g n19__clk1pt6g 39.2065
rl83 n19__clk1pt6g n20__clk1pt6g 61.7095
rl84 n19__clk1pt6g n21__clk1pt6g 35.3603
rl85 n21__clk1pt6g n22__clk1pt6g 98.0548
rl86 n22__clk1pt6g n23__clk1pt6g 22.7584
rl87 n23__clk1pt6g n24__clk1pt6g 40.0202
rl88 n24__clk1pt6g n25__clk1pt6g 38.0971
rl89 n25__clk1pt6g n26__clk1pt6g 12.5
rl90 n24__clk1pt6g n27__clk1pt6g 32.0714
rl91 n24__clk1pt6g n28__clk1pt6g 72.348
rl92 n28__clk1pt6g n29__clk1pt6g 38.0971
rl93 n29__clk1pt6g n30__clk1pt6g 12.5
rl94 n26__clk1pt6g n17__clk1pt6g 13.8175
rl95 n27__clk1pt6g n19__clk1pt6g 32.9951
rl96 n28__clk1pt6g n31__clk1pt6g 40.0202
rl97 n31__clk1pt6g n32__clk1pt6g 22.7584
rl98 n32__clk1pt6g n33__clk1pt6g 33.5925
rl99 n30__clk1pt6g n16__clk1pt6g 13.8175
rl100 n32__clk1pt6g n34__clk1pt6g 75.3901
rl101 n34__clk1pt6g n35__clk1pt6g 22.7584
rl102 n35__clk1pt6g n36__clk1pt6g 40.0202
rl103 n36__clk1pt6g n37__clk1pt6g 38.0971
rl104 n37__clk1pt6g n38__clk1pt6g 12.5
rl105 n33__clk1pt6g n22__clk1pt6g 33.5925
rl106 n36__clk1pt6g n39__clk1pt6g 32.0714
rl107 n36__clk1pt6g n40__clk1pt6g 72.348
rl108 n40__clk1pt6g n41__clk1pt6g 38.0971
rl109 n41__clk1pt6g n42__clk1pt6g 12.5
rl110 n38__clk1pt6g n15__clk1pt6g 13.8175
rl111 n39__clk1pt6g n28__clk1pt6g 32.0714
rl112 n40__clk1pt6g n43__clk1pt6g 40.0202
rl113 n43__clk1pt6g n44__clk1pt6g 22.7584
rl114 n44__clk1pt6g n45__clk1pt6g 33.5925
rl115 n42__clk1pt6g n14__clk1pt6g 13.8175
rl116 n44__clk1pt6g n46__clk1pt6g 75.3901
rl117 n46__clk1pt6g n47__clk1pt6g 22.7584
rl118 n47__clk1pt6g n48__clk1pt6g 40.0202
rl119 n48__clk1pt6g n49__clk1pt6g 38.0971
rl120 n49__clk1pt6g n50__clk1pt6g 12.5
rl121 n45__clk1pt6g n34__clk1pt6g 33.5925
rl122 n48__clk1pt6g n51__clk1pt6g 32.0714
rl123 n48__clk1pt6g n52__clk1pt6g 72.348
rl124 n52__clk1pt6g n53__clk1pt6g 38.0971
rl125 n53__clk1pt6g n54__clk1pt6g 12.5
rl126 n50__clk1pt6g n13__clk1pt6g 13.8175
rl127 n51__clk1pt6g n40__clk1pt6g 32.0714
rl128 n52__clk1pt6g n55__clk1pt6g 40.0202
rl129 n55__clk1pt6g n56__clk1pt6g 22.7584
rl130 n56__clk1pt6g n57__clk1pt6g 33.5925
rl131 n54__clk1pt6g n12__clk1pt6g 13.8175
rl132 n56__clk1pt6g n58__clk1pt6g 75.3901
rl133 n58__clk1pt6g n59__clk1pt6g 22.7584
rl134 n59__clk1pt6g n60__clk1pt6g 40.0202
rl135 n60__clk1pt6g n61__clk1pt6g 38.0971
rl136 n61__clk1pt6g n62__clk1pt6g 12.5
rl137 n57__clk1pt6g n46__clk1pt6g 33.5925
rl138 n60__clk1pt6g n63__clk1pt6g 32.0714
rl139 n60__clk1pt6g n64__clk1pt6g 72.348
rl140 n64__clk1pt6g n65__clk1pt6g 38.0971
rl141 n65__clk1pt6g n66__clk1pt6g 12.5
rl142 n62__clk1pt6g n11__clk1pt6g 13.8175
rl143 n63__clk1pt6g n52__clk1pt6g 32.0714
rl144 n64__clk1pt6g n67__clk1pt6g 40.0202
rl145 n67__clk1pt6g n68__clk1pt6g 22.7584
rl146 n68__clk1pt6g n69__clk1pt6g 33.5925
rl147 n66__clk1pt6g n10__clk1pt6g 13.8175
rl148 n68__clk1pt6g n70__clk1pt6g 75.3901
rl149 n70__clk1pt6g n71__clk1pt6g 22.7584
rl150 n71__clk1pt6g n72__clk1pt6g 40.0202
rl151 n72__clk1pt6g n73__clk1pt6g 38.0971
rl152 n73__clk1pt6g n74__clk1pt6g 12.5
rl153 n69__clk1pt6g n58__clk1pt6g 33.5925
rl154 n72__clk1pt6g n75__clk1pt6g 32.0714
rl155 n72__clk1pt6g n76__clk1pt6g 72.348
rl156 n76__clk1pt6g n77__clk1pt6g 38.0971
rl157 n77__clk1pt6g n78__clk1pt6g 12.5
rl158 n74__clk1pt6g n9__clk1pt6g 13.8175
rl159 n75__clk1pt6g n64__clk1pt6g 32.0714
rl160 n76__clk1pt6g n79__clk1pt6g 40.0202
rl161 n79__clk1pt6g n80__clk1pt6g 22.7584
rl162 n80__clk1pt6g n81__clk1pt6g 33.5925
rl163 n78__clk1pt6g n8__clk1pt6g 13.8175
rl164 n80__clk1pt6g n82__clk1pt6g 75.3901
rl165 n82__clk1pt6g n83__clk1pt6g 22.7584
rl166 n83__clk1pt6g n84__clk1pt6g 40.0202
rl167 n84__clk1pt6g n85__clk1pt6g 38.0971
rl168 n85__clk1pt6g n86__clk1pt6g 12.5
rl169 n81__clk1pt6g n70__clk1pt6g 33.5925
rl170 n84__clk1pt6g n87__clk1pt6g 32.0714
rl171 n84__clk1pt6g n88__clk1pt6g 72.348
rl172 n88__clk1pt6g n89__clk1pt6g 38.0971
rl173 n89__clk1pt6g n90__clk1pt6g 12.5
rl174 n86__clk1pt6g n7__clk1pt6g 13.8175
rl175 n87__clk1pt6g n76__clk1pt6g 32.0714
rl176 n88__clk1pt6g n91__clk1pt6g 40.0202
rl177 n91__clk1pt6g n92__clk1pt6g 22.7584
rl178 n92__clk1pt6g n93__clk1pt6g 33.5925
rl179 n90__clk1pt6g n6__clk1pt6g 13.8175
rl180 n92__clk1pt6g n94__clk1pt6g 75.3901
rl181 n94__clk1pt6g n95__clk1pt6g 22.7584
rl182 n95__clk1pt6g n96__clk1pt6g 40.0202
rl183 n96__clk1pt6g n97__clk1pt6g 38.0971
rl184 n97__clk1pt6g n98__clk1pt6g 12.5
rl185 n93__clk1pt6g n82__clk1pt6g 33.5925
rl186 n96__clk1pt6g n99__clk1pt6g 32.0714
rl187 n96__clk1pt6g n100__clk1pt6g 72.348
rl188 n100__clk1pt6g n101__clk1pt6g 38.0971
rl189 n101__clk1pt6g n102__clk1pt6g 12.5
rl190 n98__clk1pt6g n5__clk1pt6g 13.8175
rl191 n99__clk1pt6g n88__clk1pt6g 32.0714
rl192 n100__clk1pt6g n103__clk1pt6g 40.0202
rl193 n103__clk1pt6g n104__clk1pt6g 22.7584
rl194 n104__clk1pt6g n105__clk1pt6g 33.5925
rl195 n100__clk1pt6g n106__clk1pt6g 32.0714
rl196 n102__clk1pt6g n4__clk1pt6g 13.8175
rl197 n104__clk1pt6g n107__clk1pt6g 86.0676
rl198 n105__clk1pt6g n94__clk1pt6g 33.5925
rl199 n106__clk1pt6g n2__clk1pt6g 27.9842
rl200 n107__clk1pt6g n1__clk1pt6g 9.1667
rl201 n6__clk100m n7__clk100m 71.1559
rl202 n6__clk100m_b n7__clk100m_b 69.2328
rl203 n7__clk100m_b n8__clk100m_b 111.54
rl204 n108__clk1pt6g n109__clk1pt6g 42.1154
rl205 n109__clk1pt6g n110__clk1pt6g 40.1923
rl206 n110__clk1pt6g n111__clk1pt6g 106.321
rl207 n111__clk1pt6g n112__clk1pt6g 76.5385
rl208 n112__clk1pt6g n113__clk1pt6g 76.5385
rl209 n113__clk1pt6g n114__clk1pt6g 76.5385
rl210 n114__clk1pt6g n115__clk1pt6g 76.5385
rl211 n115__clk1pt6g n116__clk1pt6g 76.5385
rl212 n116__clk1pt6g n117__clk1pt6g 76.5385
rl213 n117__clk1pt6g n118__clk1pt6g 76.5385
rl214 n118__clk1pt6g n119__clk1pt6g 76.5385
rl215 n119__clk1pt6g n120__clk1pt6g 76.5385
rl216 n120__clk1pt6g n121__clk1pt6g 76.5385
rl217 n121__clk1pt6g n122__clk1pt6g 76.5385
rl218 n122__clk1pt6g n123__clk1pt6g 76.5385
rl219 n123__clk1pt6g n124__clk1pt6g 76.5385
rl220 n124__clk1pt6g n125__clk1pt6g 106.321
rl221 n125__clk1pt6g n126__clk1pt6g 37.2834
rl222 n126__clk1pt6g n127__clk1pt6g 72.0819
rl223 n126__clk1pt6g n128__clk1pt6g 37.2834
rl224 n128__clk1pt6g n129__clk1pt6g 98.0548
rl225 n129__clk1pt6g n130__clk1pt6g 22.7584
rl226 n130__clk1pt6g n131__clk1pt6g 40.0202
rl227 n131__clk1pt6g n132__clk1pt6g 38.0971
rl228 n132__clk1pt6g n133__clk1pt6g 12.5
rl229 n131__clk1pt6g n134__clk1pt6g 32.0714
rl230 n131__clk1pt6g n135__clk1pt6g 72.348
rl231 n135__clk1pt6g n136__clk1pt6g 38.0971
rl232 n136__clk1pt6g n137__clk1pt6g 12.5
rl233 n133__clk1pt6g n124__clk1pt6g 13.8175
rl234 n134__clk1pt6g n126__clk1pt6g 32.9951
rl235 n135__clk1pt6g n138__clk1pt6g 40.0202
rl236 n138__clk1pt6g n139__clk1pt6g 22.7584
rl237 n139__clk1pt6g n140__clk1pt6g 33.5925
rl238 n137__clk1pt6g n123__clk1pt6g 13.8175
rl239 n139__clk1pt6g n141__clk1pt6g 75.3901
rl240 n141__clk1pt6g n142__clk1pt6g 22.7584
rl241 n142__clk1pt6g n143__clk1pt6g 40.0202
rl242 n143__clk1pt6g n144__clk1pt6g 38.0971
rl243 n144__clk1pt6g n145__clk1pt6g 12.5
rl244 n140__clk1pt6g n129__clk1pt6g 33.5925
rl245 n143__clk1pt6g n146__clk1pt6g 32.0714
rl246 n143__clk1pt6g n147__clk1pt6g 72.348
rl247 n147__clk1pt6g n148__clk1pt6g 38.0971
rl248 n148__clk1pt6g n149__clk1pt6g 12.5
rl249 n145__clk1pt6g n122__clk1pt6g 13.8175
rl250 n146__clk1pt6g n135__clk1pt6g 32.0714
rl251 n147__clk1pt6g n150__clk1pt6g 40.0202
rl252 n150__clk1pt6g n151__clk1pt6g 22.7584
rl253 n151__clk1pt6g n152__clk1pt6g 33.5925
rl254 n149__clk1pt6g n121__clk1pt6g 13.8175
rl255 n151__clk1pt6g n153__clk1pt6g 75.3901
rl256 n153__clk1pt6g n154__clk1pt6g 22.7584
rl257 n154__clk1pt6g n155__clk1pt6g 40.0202
rl258 n155__clk1pt6g n156__clk1pt6g 38.0971
rl259 n156__clk1pt6g n157__clk1pt6g 12.5
rl260 n152__clk1pt6g n141__clk1pt6g 33.5925
rl261 n155__clk1pt6g n158__clk1pt6g 32.0714
rl262 n155__clk1pt6g n159__clk1pt6g 72.348
rl263 n159__clk1pt6g n160__clk1pt6g 38.0971
rl264 n160__clk1pt6g n161__clk1pt6g 12.5
rl265 n157__clk1pt6g n120__clk1pt6g 13.8175
rl266 n158__clk1pt6g n147__clk1pt6g 32.0714
rl267 n159__clk1pt6g n162__clk1pt6g 40.0202
rl268 n162__clk1pt6g n163__clk1pt6g 22.7584
rl269 n163__clk1pt6g n164__clk1pt6g 33.5925
rl270 n161__clk1pt6g n119__clk1pt6g 13.8175
rl271 n163__clk1pt6g n165__clk1pt6g 75.3901
rl272 n165__clk1pt6g n166__clk1pt6g 22.7584
rl273 n166__clk1pt6g n167__clk1pt6g 40.0202
rl274 n167__clk1pt6g n168__clk1pt6g 38.0971
rl275 n168__clk1pt6g n169__clk1pt6g 12.5
rl276 n164__clk1pt6g n153__clk1pt6g 33.5925
rl277 n167__clk1pt6g n170__clk1pt6g 32.0714
rl278 n167__clk1pt6g n171__clk1pt6g 72.348
rl279 n171__clk1pt6g n172__clk1pt6g 38.0971
rl280 n172__clk1pt6g n173__clk1pt6g 12.5
rl281 n169__clk1pt6g n118__clk1pt6g 13.8175
rl282 n170__clk1pt6g n159__clk1pt6g 32.0714
rl283 n171__clk1pt6g n174__clk1pt6g 40.0202
rl284 n174__clk1pt6g n175__clk1pt6g 22.7584
rl285 n175__clk1pt6g n176__clk1pt6g 33.5925
rl286 n173__clk1pt6g n117__clk1pt6g 13.8175
rl287 n175__clk1pt6g n177__clk1pt6g 75.3901
rl288 n177__clk1pt6g n178__clk1pt6g 22.7584
rl289 n178__clk1pt6g n179__clk1pt6g 40.0202
rl290 n179__clk1pt6g n180__clk1pt6g 38.0971
rl291 n180__clk1pt6g n181__clk1pt6g 12.5
rl292 n176__clk1pt6g n165__clk1pt6g 33.5925
rl293 n179__clk1pt6g n182__clk1pt6g 32.0714
rl294 n179__clk1pt6g n183__clk1pt6g 72.348
rl295 n183__clk1pt6g n184__clk1pt6g 38.0971
rl296 n184__clk1pt6g n185__clk1pt6g 12.5
rl297 n181__clk1pt6g n116__clk1pt6g 13.8175
rl298 n182__clk1pt6g n171__clk1pt6g 32.0714
rl299 n183__clk1pt6g n186__clk1pt6g 40.0202
rl300 n186__clk1pt6g n187__clk1pt6g 22.7584
rl301 n187__clk1pt6g n188__clk1pt6g 33.5925
rl302 n185__clk1pt6g n115__clk1pt6g 13.8175
rl303 n187__clk1pt6g n189__clk1pt6g 75.3901
rl304 n189__clk1pt6g n190__clk1pt6g 22.7584
rl305 n190__clk1pt6g n191__clk1pt6g 40.0202
rl306 n191__clk1pt6g n192__clk1pt6g 38.0971
rl307 n192__clk1pt6g n193__clk1pt6g 12.5
rl308 n188__clk1pt6g n177__clk1pt6g 33.5925
rl309 n191__clk1pt6g n194__clk1pt6g 32.0714
rl310 n191__clk1pt6g n195__clk1pt6g 72.348
rl311 n195__clk1pt6g n196__clk1pt6g 38.0971
rl312 n196__clk1pt6g n197__clk1pt6g 12.5
rl313 n193__clk1pt6g n114__clk1pt6g 13.8175
rl314 n194__clk1pt6g n183__clk1pt6g 32.0714
rl315 n195__clk1pt6g n198__clk1pt6g 40.0202
rl316 n198__clk1pt6g n199__clk1pt6g 22.7584
rl317 n199__clk1pt6g n200__clk1pt6g 33.5925
rl318 n197__clk1pt6g n113__clk1pt6g 13.8175
rl319 n199__clk1pt6g n201__clk1pt6g 75.3901
rl320 n201__clk1pt6g n202__clk1pt6g 22.7584
rl321 n202__clk1pt6g n203__clk1pt6g 40.0202
rl322 n203__clk1pt6g n204__clk1pt6g 38.0971
rl323 n204__clk1pt6g n205__clk1pt6g 12.5
rl324 n200__clk1pt6g n189__clk1pt6g 33.5925
rl325 n203__clk1pt6g n206__clk1pt6g 32.0714
rl326 n203__clk1pt6g n207__clk1pt6g 72.348
rl327 n207__clk1pt6g n208__clk1pt6g 38.0971
rl328 n208__clk1pt6g n209__clk1pt6g 12.5
rl329 n205__clk1pt6g n112__clk1pt6g 13.8175
rl330 n206__clk1pt6g n195__clk1pt6g 32.0714
rl331 n207__clk1pt6g n210__clk1pt6g 40.0202
rl332 n210__clk1pt6g n211__clk1pt6g 22.7584
rl333 n211__clk1pt6g n212__clk1pt6g 33.5925
rl334 n207__clk1pt6g n213__clk1pt6g 32.0714
rl335 n209__clk1pt6g n111__clk1pt6g 13.8175
rl336 n211__clk1pt6g n214__clk1pt6g 86.0676
rl337 n212__clk1pt6g n201__clk1pt6g 33.5925
rl338 n213__clk1pt6g n109__clk1pt6g 27.9842
rl339 n214__clk1pt6g n108__clk1pt6g 9.1667
rl340 n215__clk1pt6g n216__clk1pt6g 42.1154
rl341 n216__clk1pt6g n217__clk1pt6g 40.1923
rl342 n217__clk1pt6g n218__clk1pt6g 98.629
rl343 n218__clk1pt6g n219__clk1pt6g 76.5385
rl344 n219__clk1pt6g n220__clk1pt6g 76.5385
rl345 n220__clk1pt6g n221__clk1pt6g 76.5385
rl346 n221__clk1pt6g n222__clk1pt6g 76.5385
rl347 n222__clk1pt6g n223__clk1pt6g 76.5385
rl348 n223__clk1pt6g n224__clk1pt6g 98.629
rl349 n224__clk1pt6g n225__clk1pt6g 37.2834
rl350 n225__clk1pt6g n226__clk1pt6g 53.7308
rl351 n225__clk1pt6g n227__clk1pt6g 37.2834
rl352 n227__clk1pt6g n228__clk1pt6g 98.0548
rl353 n228__clk1pt6g n229__clk1pt6g 22.7584
rl354 n229__clk1pt6g n230__clk1pt6g 40.0202
rl355 n230__clk1pt6g n231__clk1pt6g 38.0971
rl356 n231__clk1pt6g n232__clk1pt6g 9.1667
rl357 n230__clk1pt6g n233__clk1pt6g 32.0714
rl358 n230__clk1pt6g n234__clk1pt6g 72.348
rl359 n234__clk1pt6g n235__clk1pt6g 38.0971
rl360 n235__clk1pt6g n236__clk1pt6g 9.1667
rl361 n232__clk1pt6g n223__clk1pt6g 10.4842
rl362 n233__clk1pt6g n225__clk1pt6g 32.9951
rl363 n234__clk1pt6g n237__clk1pt6g 40.0202
rl364 n237__clk1pt6g n238__clk1pt6g 22.7584
rl365 n238__clk1pt6g n239__clk1pt6g 33.5925
rl366 n236__clk1pt6g n222__clk1pt6g 10.4842
rl367 n238__clk1pt6g n240__clk1pt6g 75.3901
rl368 n240__clk1pt6g n241__clk1pt6g 22.7584
rl369 n241__clk1pt6g n242__clk1pt6g 40.0202
rl370 n242__clk1pt6g n243__clk1pt6g 38.0971
rl371 n243__clk1pt6g n244__clk1pt6g 9.1667
rl372 n239__clk1pt6g n228__clk1pt6g 33.5925
rl373 n242__clk1pt6g n245__clk1pt6g 32.0714
rl374 n242__clk1pt6g n246__clk1pt6g 72.348
rl375 n246__clk1pt6g n247__clk1pt6g 38.0971
rl376 n247__clk1pt6g n248__clk1pt6g 9.1667
rl377 n244__clk1pt6g n221__clk1pt6g 10.4842
rl378 n245__clk1pt6g n234__clk1pt6g 32.0714
rl379 n246__clk1pt6g n249__clk1pt6g 40.0202
rl380 n249__clk1pt6g n250__clk1pt6g 22.7584
rl381 n250__clk1pt6g n251__clk1pt6g 33.5925
rl382 n248__clk1pt6g n220__clk1pt6g 10.4842
rl383 n250__clk1pt6g n252__clk1pt6g 75.3901
rl384 n252__clk1pt6g n253__clk1pt6g 22.7584
rl385 n253__clk1pt6g n254__clk1pt6g 40.0202
rl386 n254__clk1pt6g n255__clk1pt6g 38.0971
rl387 n255__clk1pt6g n256__clk1pt6g 9.1667
rl388 n251__clk1pt6g n240__clk1pt6g 33.5925
rl389 n254__clk1pt6g n257__clk1pt6g 32.0714
rl390 n254__clk1pt6g n258__clk1pt6g 72.348
rl391 n258__clk1pt6g n259__clk1pt6g 38.0971
rl392 n259__clk1pt6g n260__clk1pt6g 9.1667
rl393 n256__clk1pt6g n219__clk1pt6g 10.4842
rl394 n257__clk1pt6g n246__clk1pt6g 32.0714
rl395 n258__clk1pt6g n261__clk1pt6g 40.0202
rl396 n261__clk1pt6g n262__clk1pt6g 22.7584
rl397 n262__clk1pt6g n263__clk1pt6g 33.5925
rl398 n258__clk1pt6g n264__clk1pt6g 32.0714
rl399 n260__clk1pt6g n218__clk1pt6g 10.4842
rl400 n262__clk1pt6g n265__clk1pt6g 86.0676
rl401 n263__clk1pt6g n252__clk1pt6g 33.5925
rl402 n264__clk1pt6g n216__clk1pt6g 27.9842
rl403 n265__clk1pt6g n215__clk1pt6g 9.1667
rl404 n6__rst n7__rst 38.1757
rl405 n7__rst n8__rst 49.3144
rl406 n7__rst n9__rst 80.4834
rl407 n9__rst n10__rst 111.54
rl408 n4__rst_b n5__rst_b 126.923
rl409 n5__rst_b n6__rst_b 69.2328
rl410 i33__i28__x n2__i33__i28__x 99.7141
rl411 n2__i33__i28__x n3__i33__i28__x 50.1123
rl412 n2__i33__i28__x n4__i33__i28__x 65.0987
rl413 n9__clk100m_b n10__clk100m_b 71.1559
rl414 n8__clk100m n9__clk100m 69.2328
rl415 n9__clk100m n10__clk100m 111.54
rl416 i28__net1 n2__i28__net1 69.0385
rl417 n2__i28__net1 n3__i28__net1 70.9615
rl418 n3__i28__net1 n4__i28__net1 120.719
rl419 n4__i28__net1 n5__i28__net1 56.9251
rl420 n5__i28__net1 n6__i28__net1 56.9251
rl421 n6__i28__net1 n7__i28__net1 108.732
rl422 n5__i28__net1 n8__i28__net1 33.1687
rl423 n7__i28__net1 i28__net1 9.1667
rl424 n8__i28__net1 n2__i28__net1 27.9842
rl425 net18 n2__net18 85.7713
rl426 n2__net18 n3__net18 58.8482
rl427 n4__en_b n5__en_b 203.848
rl428 n4__en_b n6__en_b 126.923
rl429 i33__i26__net1 n2__i33__i26__net1 72.3097
rl430 n2__i33__i26__net1 n3__i33__i26__net1 72.3097
rl431 n266__clk1pt6g n267__clk1pt6g 71.1559
rl432 net23 n2__net23 69.2328
rl433 n2__net23 n3__net23 111.54
rl434 n4__en n5__en 157.694
rl435 n4__en n6__en 126.923
rl436 net29 n2__net29 111.54
rl437 n268__clk1pt6g n269__clk1pt6g 111.54
rl438 n11__clk100m n12__clk100m 71.1559
rl439 n11__clk100m_b n12__clk100m_b 69.2328
rl440 n12__clk100m_b n13__clk100m_b 111.54
rl441 n14__clk100m_b n15__clk100m_b 113.464
rl442 n14__clk100m_b n16__clk100m_b 126.923
rl443 i40__i57__x n2__i40__i57__x 35.7713
rl444 n2__i40__i57__x n3__i40__i57__x 37.6944
rl445 n11__rst n12__rst 38.1757
rl446 n12__rst n13__rst 49.3144
rl447 n12__rst n14__rst 80.4834
rl448 n14__rst n15__rst 111.54
rl449 n270__clk1pt6g n271__clk1pt6g 158.335
rl450 n271__clk1pt6g n272__clk1pt6g 27.5641
rl451 n272__clk1pt6g n273__clk1pt6g 23.7402
rl452 n273__clk1pt6g n274__clk1pt6g 51.6011
rl453 n273__clk1pt6g n275__clk1pt6g 97.6734
rl454 n275__clk1pt6g n276__clk1pt6g 51.6131
rl455 n276__clk1pt6g n271__clk1pt6g 24.6956
rl456 net22 n2__net22 120.719
rl457 n2__net22 n3__net22 25.7494
rl458 n3__net22 n4__net22 51.4019
rl459 n3__net22 n5__net22 88.6921
rl460 n5__net22 net22 9.1667
rl461 n13__clk100m n14__clk100m 126.923
rl462 n14__clk100m n15__clk100m 69.2328
rl463 i29__i130__x n2__i29__i130__x 99.7141
rl464 n2__i29__i130__x n3__i29__i130__x 50.1123
rl465 n2__i29__i130__x n4__i29__i130__x 65.0987
rl466 n7__rst_b n8__rst_b 126.923
rl467 n8__rst_b n9__rst_b 69.2328
rl468 i33__i26__x n2__i33__i26__x 99.7141
rl469 n2__i33__i26__x n3__i33__i26__x 50.1123
rl470 n2__i33__i26__x n4__i33__i26__x 65.0987
rl471 n277__clk1pt6g n278__clk1pt6g 111.54
rl472 n3__net29 n4__net29 111.54
rl473 n4__net23 n5__net23 71.1559
rl474 n279__clk1pt6g n280__clk1pt6g 69.2328
rl475 n280__clk1pt6g n281__clk1pt6g 111.54
rl476 n17__clk100m_b n18__clk100m_b 71.1559
rl477 n16__clk100m n17__clk100m 69.2328
rl478 n17__clk100m n18__clk100m 111.54
rl479 n1__out1 n2__out1 50.1171
rl480 n2__out1 n3__out1 40.0987
rl481 n2__out1 n4__out1 53.5603
rl482 i28__i69__x n2__i28__i69__x 67.1154
rl483 n2__i28__i69__x n3__i28__i69__x 72.8846
rl484 n3__i28__i69__x n4__i28__i69__x 120.719
rl485 n4__i28__i69__x n5__i28__i69__x 60.7713
rl486 n5__i28__i69__x n6__i28__i69__x 53.079
rl487 n6__i28__i69__x n7__i28__i69__x 108.732
rl488 n5__i28__i69__x n8__i28__i69__x 33.1687
rl489 n7__i28__i69__x i28__i69__x 9.1667
rl490 n8__i28__i69__x n2__i28__i69__x 27.9842
rl491 i29__net27 n2__i29__net27 334.618
rl492 i29__net27 n3__i29__net27 173.077
rl493 n7__en_b n8__en_b 203.848
rl494 n7__en_b n9__en_b 126.923
rl495 i33__i29__net1 n2__i33__i29__net1 72.3097
rl496 n2__i33__i29__net1 n3__i33__i29__net1 72.3097
rl497 n288__clk1pt6g n289__clk1pt6g 71.1559
rl498 n6__net23 n7__net23 69.2328
rl499 n7__net23 n8__net23 111.54
rl500 n7__en n8__en 157.694
rl501 n7__en n9__en 126.923
rl502 n5__net29 n6__net29 111.54
rl503 n290__clk1pt6g n291__clk1pt6g 111.54
rl504 n19__clk100m n20__clk100m 71.1559
rl505 n19__clk100m_b n20__clk100m_b 69.2328
rl506 n20__clk100m_b n21__clk100m_b 111.54
rl507 n22__clk100m_b n23__clk100m_b 113.464
rl508 n22__clk100m_b n24__clk100m_b 126.923
rl509 i40__i56__x n2__i40__i56__x 35.7713
rl510 n2__i40__i56__x n3__i40__i56__x 37.6944
rl511 n16__rst n17__rst 38.1757
rl512 n17__rst n18__rst 49.3144
rl513 n17__rst n19__rst 80.4834
rl514 n19__rst n20__rst 111.54
rl515 n6__net22 n7__net22 158.335
rl516 n7__net22 n8__net22 27.5641
rl517 n8__net22 n9__net22 23.7402
rl518 n9__net22 n10__net22 51.6011
rl519 n9__net22 n11__net22 97.6734
rl520 n11__net22 n12__net22 51.6131
rl521 n12__net22 n7__net22 24.6956
rl522 n292__clk1pt6g n293__clk1pt6g 109.826
rl523 n293__clk1pt6g n294__clk1pt6g 25.7494
rl524 n294__clk1pt6g n295__clk1pt6g 51.4019
rl525 n294__clk1pt6g n296__clk1pt6g 88.6921
rl526 n296__clk1pt6g n292__clk1pt6g 9.1667
rl527 n21__clk100m n22__clk100m 126.923
rl528 n22__clk100m n23__clk100m 69.2328
rl529 i29__i131__x n2__i29__i131__x 99.7141
rl530 n2__i29__i131__x n3__i29__i131__x 50.1123
rl531 n2__i29__i131__x n4__i29__i131__x 65.0987
rl532 n10__rst_b n11__rst_b 126.923
rl533 n11__rst_b n12__rst_b 69.2328
rl534 i33__i29__x n2__i33__i29__x 99.7141
rl535 n2__i33__i29__x n3__i33__i29__x 50.1123
rl536 n2__i33__i29__x n4__i33__i29__x 65.0987
rl537 n297__clk1pt6g n298__clk1pt6g 111.54
rl538 n7__net29 n8__net29 111.54
rl539 n9__net23 n10__net23 71.1559
rl540 n299__clk1pt6g n300__clk1pt6g 69.2328
rl541 n300__clk1pt6g n301__clk1pt6g 111.54
rl542 n25__clk100m_b n26__clk100m_b 71.1559
rl543 n24__clk100m n25__clk100m 69.2328
rl544 n25__clk100m n26__clk100m 111.54
rl545 n1__out2 n2__out2 50.1171
rl546 n2__out2 n3__out2 40.0987
rl547 n2__out2 n4__out2 53.5603
rl548 i29__net20 n2__i29__net20 334.618
rl549 i29__net20 n3__i29__net20 173.077
rl550 n10__en_b n11__en_b 203.848
rl551 n10__en_b n12__en_b 126.923
rl552 i33__i24__net1 n2__i33__i24__net1 72.3097
rl553 n2__i33__i24__net1 n3__i33__i24__net1 72.3097
rl554 n305__clk1pt6g n306__clk1pt6g 71.1559
rl555 n11__net23 n12__net23 69.2328
rl556 n12__net23 n13__net23 111.54
rl557 n10__en n11__en 157.694
rl558 n10__en n12__en 126.923
rl559 n9__net29 n10__net29 111.54
rl560 n307__clk1pt6g n308__clk1pt6g 111.54
rl561 n28__clk100m n29__clk100m 71.1559
rl562 n33__clk100m_b n34__clk100m_b 69.2328
rl563 n34__clk100m_b n35__clk100m_b 111.54
rl564 n36__clk100m_b n37__clk100m_b 113.464
rl565 n36__clk100m_b n38__clk100m_b 126.923
rl566 i40__i55__x n2__i40__i55__x 35.7713
rl567 n2__i40__i55__x n3__i40__i55__x 37.6944
rl568 i28__net9 n2__i28__net9 149.81
rl569 n2__i28__net9 n3__i28__net9 28.6538
rl570 n3__i28__net9 n4__i28__net9 40.0202
rl571 n4__i28__net9 n5__i28__net9 38.0971
rl572 n5__i28__net9 n6__i28__net9 120.719
rl573 n6__i28__net9 n7__i28__net9 28.079
rl574 n4__i28__net9 n8__i28__net9 156.963
rl575 n8__i28__net9 n9__i28__net9 38.0971
rl576 n9__i28__net9 n10__i28__net9 120.719
rl577 n10__i28__net9 n11__i28__net9 40.1923
rl578 n11__i28__net9 n12__i28__net9 27.9842
rl579 n7__i28__net9 n13__i28__net9 28.079
rl580 n13__i28__net9 n14__i28__net9 56.2572
rl581 n7__i28__net9 n15__i28__net9 34.6687
rl582 n11__i28__net9 n16__i28__net9 42.1154
rl583 n16__i28__net9 n17__i28__net9 120.719
rl584 n17__i28__net9 n18__i28__net9 15
rl585 n12__i28__net9 n8__i28__net9 32.0714
rl586 n14__i28__net9 n2__i28__net9 27.9842
rl587 n15__i28__net9 n4__i28__net9 32.0714
rl588 n18__i28__net9 n8__i28__net9 20.4048
rl589 n26__rst n27__rst 38.1757
rl590 n27__rst n28__rst 49.3144
rl591 n27__rst n29__rst 80.4834
rl592 n29__rst n30__rst 111.54
rl593 n30__clk100m n31__clk100m 126.923
rl594 n31__clk100m n32__clk100m 69.2328
rl595 i29__i132__x n2__i29__i132__x 99.7141
rl596 n2__i29__i132__x n3__i29__i132__x 50.1123
rl597 n2__i29__i132__x n4__i29__i132__x 65.0987
rl598 n15__rst_b n16__rst_b 126.923
rl599 n16__rst_b n17__rst_b 69.2328
rl600 i33__i24__x n2__i33__i24__x 99.7141
rl601 n2__i33__i24__x n3__i33__i24__x 50.1123
rl602 n2__i33__i24__x n4__i33__i24__x 65.0987
rl603 n37__clk100m n38__clk100m 53.7308
rl604 n38__clk100m n39__clk100m 37.2834
rl605 n39__clk100m n40__clk100m 106.321
rl606 n40__clk100m n41__clk100m 76.5385
rl607 n41__clk100m n42__clk100m 76.5385
rl608 n42__clk100m n43__clk100m 76.5385
rl609 n43__clk100m n44__clk100m 76.5385
rl610 n44__clk100m n45__clk100m 76.5385
rl611 n45__clk100m n46__clk100m 76.5385
rl612 n46__clk100m n47__clk100m 76.5385
rl613 n47__clk100m n48__clk100m 76.5385
rl614 n48__clk100m n49__clk100m 76.5385
rl615 n49__clk100m n50__clk100m 76.5385
rl616 n50__clk100m n51__clk100m 76.5385
rl617 n51__clk100m n52__clk100m 76.5385
rl618 n52__clk100m n53__clk100m 76.5385
rl619 n53__clk100m n54__clk100m 106.321
rl620 n54__clk100m n55__clk100m 40.1923
rl621 n55__clk100m n56__clk100m 42.1154
rl622 n56__clk100m n57__clk100m 98.0548
rl623 n57__clk100m n58__clk100m 22.7584
rl624 n58__clk100m n59__clk100m 40.0202
rl625 n59__clk100m n60__clk100m 38.0971
rl626 n60__clk100m n61__clk100m 12.5
rl627 n59__clk100m n62__clk100m 32.0714
rl628 n59__clk100m n63__clk100m 72.348
rl629 n63__clk100m n64__clk100m 38.0971
rl630 n64__clk100m n65__clk100m 12.5
rl631 n61__clk100m n53__clk100m 13.8175
rl632 n62__clk100m n55__clk100m 27.9842
rl633 n63__clk100m n66__clk100m 40.0202
rl634 n66__clk100m n67__clk100m 22.7584
rl635 n67__clk100m n68__clk100m 33.5925
rl636 n65__clk100m n52__clk100m 13.8175
rl637 n67__clk100m n69__clk100m 75.3901
rl638 n69__clk100m n70__clk100m 22.7584
rl639 n70__clk100m n71__clk100m 40.0202
rl640 n71__clk100m n72__clk100m 38.0971
rl641 n72__clk100m n73__clk100m 12.5
rl642 n68__clk100m n57__clk100m 33.5925
rl643 n71__clk100m n74__clk100m 32.0714
rl644 n71__clk100m n75__clk100m 72.348
rl645 n75__clk100m n76__clk100m 38.0971
rl646 n76__clk100m n77__clk100m 12.5
rl647 n73__clk100m n51__clk100m 13.8175
rl648 n74__clk100m n63__clk100m 32.0714
rl649 n75__clk100m n78__clk100m 40.0202
rl650 n78__clk100m n79__clk100m 22.7584
rl651 n79__clk100m n80__clk100m 33.5925
rl652 n77__clk100m n50__clk100m 13.8175
rl653 n79__clk100m n81__clk100m 75.3901
rl654 n81__clk100m n82__clk100m 22.7584
rl655 n82__clk100m n83__clk100m 40.0202
rl656 n83__clk100m n84__clk100m 38.0971
rl657 n84__clk100m n85__clk100m 12.5
rl658 n80__clk100m n69__clk100m 33.5925
rl659 n83__clk100m n86__clk100m 32.0714
rl660 n83__clk100m n87__clk100m 72.348
rl661 n87__clk100m n88__clk100m 38.0971
rl662 n88__clk100m n89__clk100m 12.5
rl663 n85__clk100m n49__clk100m 13.8175
rl664 n86__clk100m n75__clk100m 32.0714
rl665 n87__clk100m n90__clk100m 40.0202
rl666 n90__clk100m n91__clk100m 22.7584
rl667 n91__clk100m n92__clk100m 33.5925
rl668 n89__clk100m n48__clk100m 13.8175
rl669 n91__clk100m n93__clk100m 75.3901
rl670 n93__clk100m n94__clk100m 22.7584
rl671 n94__clk100m n95__clk100m 40.0202
rl672 n95__clk100m n96__clk100m 38.0971
rl673 n96__clk100m n97__clk100m 12.5
rl674 n92__clk100m n81__clk100m 33.5925
rl675 n95__clk100m n98__clk100m 32.0714
rl676 n95__clk100m n99__clk100m 72.348
rl677 n99__clk100m n100__clk100m 38.0971
rl678 n100__clk100m n101__clk100m 12.5
rl679 n97__clk100m n47__clk100m 13.8175
rl680 n98__clk100m n87__clk100m 32.0714
rl681 n99__clk100m n102__clk100m 40.0202
rl682 n102__clk100m n103__clk100m 22.7584
rl683 n103__clk100m n104__clk100m 33.5925
rl684 n101__clk100m n46__clk100m 13.8175
rl685 n103__clk100m n105__clk100m 75.3901
rl686 n105__clk100m n106__clk100m 22.7584
rl687 n106__clk100m n107__clk100m 40.0202
rl688 n107__clk100m n108__clk100m 38.0971
rl689 n108__clk100m n109__clk100m 12.5
rl690 n104__clk100m n93__clk100m 33.5925
rl691 n107__clk100m n110__clk100m 32.0714
rl692 n107__clk100m n111__clk100m 72.348
rl693 n111__clk100m n112__clk100m 38.0971
rl694 n112__clk100m n113__clk100m 12.5
rl695 n109__clk100m n45__clk100m 13.8175
rl696 n110__clk100m n99__clk100m 32.0714
rl697 n111__clk100m n114__clk100m 40.0202
rl698 n114__clk100m n115__clk100m 22.7584
rl699 n115__clk100m n116__clk100m 33.5925
rl700 n113__clk100m n44__clk100m 13.8175
rl701 n115__clk100m n117__clk100m 75.3901
rl702 n117__clk100m n118__clk100m 22.7584
rl703 n118__clk100m n119__clk100m 40.0202
rl704 n119__clk100m n120__clk100m 38.0971
rl705 n120__clk100m n121__clk100m 12.5
rl706 n116__clk100m n105__clk100m 33.5925
rl707 n119__clk100m n122__clk100m 32.0714
rl708 n119__clk100m n123__clk100m 72.348
rl709 n123__clk100m n124__clk100m 38.0971
rl710 n124__clk100m n125__clk100m 12.5
rl711 n121__clk100m n43__clk100m 13.8175
rl712 n122__clk100m n111__clk100m 32.0714
rl713 n123__clk100m n126__clk100m 40.0202
rl714 n126__clk100m n127__clk100m 22.7584
rl715 n127__clk100m n128__clk100m 33.5925
rl716 n125__clk100m n42__clk100m 13.8175
rl717 n127__clk100m n129__clk100m 75.3901
rl718 n129__clk100m n130__clk100m 22.7584
rl719 n130__clk100m n131__clk100m 40.0202
rl720 n131__clk100m n132__clk100m 38.0971
rl721 n132__clk100m n133__clk100m 12.5
rl722 n128__clk100m n117__clk100m 33.5925
rl723 n131__clk100m n134__clk100m 32.0714
rl724 n131__clk100m n135__clk100m 72.348
rl725 n135__clk100m n136__clk100m 38.0971
rl726 n136__clk100m n137__clk100m 12.5
rl727 n133__clk100m n41__clk100m 13.8175
rl728 n134__clk100m n123__clk100m 32.0714
rl729 n135__clk100m n138__clk100m 40.0202
rl730 n138__clk100m n139__clk100m 22.7584
rl731 n139__clk100m n140__clk100m 33.5925
rl732 n135__clk100m n141__clk100m 32.0714
rl733 n137__clk100m n40__clk100m 13.8175
rl734 n139__clk100m n142__clk100m 98.0548
rl735 n142__clk100m n143__clk100m 10
rl736 n140__clk100m n129__clk100m 33.5925
rl737 n141__clk100m n38__clk100m 32.9951
rl738 n143__clk100m n38__clk100m 24.2065
rl739 n309__clk1pt6g n310__clk1pt6g 111.54
rl740 n11__net29 n12__net29 111.54
rl741 n14__net23 n15__net23 71.1559
rl742 n311__clk1pt6g n312__clk1pt6g 69.2328
rl743 n312__clk1pt6g n313__clk1pt6g 111.54
rl744 n40__clk100m_b n41__clk100m_b 71.1559
rl745 n144__clk100m n145__clk100m 69.2328
rl746 n145__clk100m n146__clk100m 111.54
rl747 n1__out3 n2__out3 50.1171
rl748 n2__out3 n3__out3 40.0987
rl749 n2__out3 n4__out3 53.5603
rl750 i28__net15 n2__i28__net15 69.0385
rl751 n2__i28__net15 n3__i28__net15 70.9615
rl752 n3__i28__net15 n4__i28__net15 120.719
rl753 n4__i28__net15 n5__i28__net15 56.9251
rl754 n5__i28__net15 n6__i28__net15 56.9251
rl755 n6__i28__net15 n7__i28__net15 108.732
rl756 n5__i28__net15 n8__i28__net15 33.1687
rl757 n7__i28__net15 i28__net15 9.1667
rl758 n8__i28__net15 n2__i28__net15 27.9842
rl759 i29__net10 n2__i29__net10 334.618
rl760 i29__net10 n3__i29__net10 173.077
rl761 n13__en_b n14__en_b 203.848
rl762 n13__en_b n15__en_b 126.923
rl763 i33__i25__net1 n2__i33__i25__net1 72.3097
rl764 n2__i33__i25__net1 n3__i33__i25__net1 72.3097
rl765 n314__clk1pt6g n315__clk1pt6g 71.1559
rl766 n16__net23 n17__net23 69.2328
rl767 n17__net23 n18__net23 111.54
rl768 n13__en n14__en 157.694
rl769 n13__en n15__en 126.923
rl770 n13__net29 n14__net29 111.54
rl771 n316__clk1pt6g n317__clk1pt6g 111.54
rl772 n148__clk100m n149__clk100m 71.1559
rl773 n47__clk100m_b n48__clk100m_b 69.2328
rl774 n48__clk100m_b n49__clk100m_b 111.54
rl775 n50__clk100m_b n51__clk100m_b 113.464
rl776 n50__clk100m_b n52__clk100m_b 126.923
rl777 i40__i54__x n2__i40__i54__x 35.7713
rl778 n2__i40__i54__x n3__i40__i54__x 37.6944
rl779 n42__rst n43__rst 38.1757
rl780 n43__rst n44__rst 49.3144
rl781 n43__rst n45__rst 80.4834
rl782 n45__rst n46__rst 111.54
rl783 i28__net20 n2__i28__net20 125.643
rl784 n2__i28__net20 n3__i28__net20 27.5641
rl785 n3__i28__net20 n4__i28__net20 23.7402
rl786 n4__i28__net20 n5__i28__net20 51.6011
rl787 n4__i28__net20 n6__i28__net20 97.6734
rl788 n6__i28__net20 n7__i28__net20 51.6131
rl789 n7__i28__net20 n2__i28__net20 24.6956
rl790 n19__i28__net9 n20__i28__net9 120.719
rl791 n20__i28__net9 n21__i28__net9 25.7494
rl792 n21__i28__net9 n22__i28__net9 51.4019
rl793 n21__i28__net9 n23__i28__net9 88.6921
rl794 n23__i28__net9 n19__i28__net9 9.1667
rl795 n150__clk100m n151__clk100m 126.923
rl796 n151__clk100m n152__clk100m 69.2328
rl797 i29__i133__x n2__i29__i133__x 99.7141
rl798 n2__i29__i133__x n3__i29__i133__x 50.1123
rl799 n2__i29__i133__x n4__i29__i133__x 65.0987
rl800 n25__rst_b n26__rst_b 126.923
rl801 n26__rst_b n27__rst_b 69.2328
rl802 i33__i25__x n2__i33__i25__x 99.7141
rl803 n2__i33__i25__x n3__i33__i25__x 50.1123
rl804 n2__i33__i25__x n4__i33__i25__x 65.0987
rl805 n318__clk1pt6g n319__clk1pt6g 111.54
rl806 n28__net29 n29__net29 111.54
rl807 n46__net23 n47__net23 71.1559
rl808 n320__clk1pt6g n321__clk1pt6g 69.2328
rl809 n321__clk1pt6g n322__clk1pt6g 111.54
rl810 n57__clk100m_b n58__clk100m_b 71.1559
rl811 n157__clk100m n158__clk100m 69.2328
rl812 n158__clk100m n159__clk100m 111.54
rl813 n1__out4 n2__out4 50.1171
rl814 n2__out4 n3__out4 40.0987
rl815 n2__out4 n4__out4 53.5603
rl816 i28__i70__x n2__i28__i70__x 67.1154
rl817 n2__i28__i70__x n3__i28__i70__x 72.8846
rl818 n3__i28__i70__x n4__i28__i70__x 120.719
rl819 n4__i28__i70__x n5__i28__i70__x 60.7713
rl820 n5__i28__i70__x n6__i28__i70__x 53.079
rl821 n6__i28__i70__x n7__i28__i70__x 108.732
rl822 n5__i28__i70__x n8__i28__i70__x 33.1687
rl823 n7__i28__i70__x i28__i70__x 9.1667
rl824 n8__i28__i70__x n2__i28__i70__x 27.9842
rl825 i29__net17 n2__i29__net17 334.618
rl826 i29__net17 n3__i29__net17 173.077
rl827 n16__en_b n17__en_b 203.848
rl828 n16__en_b n18__en_b 126.923
rl829 i33__i23__net1 n2__i33__i23__net1 72.3097
rl830 n2__i33__i23__net1 n3__i33__i23__net1 72.3097
rl831 n325__clk1pt6g n326__clk1pt6g 71.1559
rl832 n53__net23 n54__net23 69.2328
rl833 n54__net23 n55__net23 111.54
rl834 n16__en n17__en 157.694
rl835 n16__en n18__en 126.923
rl836 n30__net29 n31__net29 111.54
rl837 n328__clk1pt6g n329__clk1pt6g 111.54
rl838 n161__clk100m n162__clk100m 71.1559
rl839 n64__clk100m_b n65__clk100m_b 69.2328
rl840 n65__clk100m_b n66__clk100m_b 111.54
rl841 n67__clk100m_b n68__clk100m_b 113.464
rl842 n67__clk100m_b n69__clk100m_b 126.923
rl843 i40__i53__x n2__i40__i53__x 35.7713
rl844 n2__i40__i53__x n3__i40__i53__x 37.6944
rl845 n24__i28__net9 n25__i28__net9 125.643
rl846 n25__i28__net9 n26__i28__net9 27.5641
rl847 n26__i28__net9 n27__i28__net9 23.7402
rl848 n27__i28__net9 n28__i28__net9 51.6011
rl849 n27__i28__net9 n29__i28__net9 97.6734
rl850 n29__i28__net9 n30__i28__net9 51.6131
rl851 n30__i28__net9 n25__i28__net9 24.6956
rl852 n8__i28__net20 n9__i28__net20 109.826
rl853 n9__i28__net20 n10__i28__net20 25.7494
rl854 n10__i28__net20 n11__i28__net20 51.4019
rl855 n10__i28__net20 n12__i28__net20 88.6921
rl856 n12__i28__net20 n8__i28__net20 9.1667
rl857 n58__rst n59__rst 38.1757
rl858 n59__rst n60__rst 49.3144
rl859 n59__rst n61__rst 80.4834
rl860 n61__rst n62__rst 111.54
rl861 n165__clk100m n166__clk100m 126.923
rl862 n166__clk100m n167__clk100m 69.2328
rl863 i29__i134__x n2__i29__i134__x 99.7141
rl864 n2__i29__i134__x n3__i29__i134__x 50.1123
rl865 n2__i29__i134__x n4__i29__i134__x 65.0987
rl866 n35__rst_b n36__rst_b 126.923
rl867 n36__rst_b n37__rst_b 69.2328
rl868 i33__i23__x n2__i33__i23__x 99.7141
rl869 n2__i33__i23__x n3__i33__i23__x 50.1123
rl870 n2__i33__i23__x n4__i33__i23__x 65.0987
rl871 n339__clk1pt6g n340__clk1pt6g 111.54
rl872 n35__net29 n36__net29 111.54
rl873 n57__net23 n58__net23 71.1559
rl874 n343__clk1pt6g n344__clk1pt6g 69.2328
rl875 n344__clk1pt6g n345__clk1pt6g 111.54
rl876 n71__clk100m_b n72__clk100m_b 71.1559
rl877 n172__clk100m n173__clk100m 69.2328
rl878 n173__clk100m n174__clk100m 111.54
rl879 n1__out5 n2__out5 50.1171
rl880 n2__out5 n3__out5 40.0987
rl881 n2__out5 n4__out5 53.5603
rl882 i29__net30 n2__i29__net30 334.618
rl883 i29__net30 n3__i29__net30 173.077
rl884 n19__en_b n20__en_b 203.848
rl885 n19__en_b n21__en_b 126.923
rl886 i33__i30__net1 n2__i33__i30__net1 72.3097
rl887 n2__i33__i30__net1 n3__i33__i30__net1 72.3097
rl888 n349__clk1pt6g n350__clk1pt6g 71.1559
rl889 n62__net23 n63__net23 69.2328
rl890 n63__net23 n64__net23 111.54
rl891 n19__en n20__en 157.694
rl892 n19__en n21__en 126.923
rl893 n39__net29 n40__net29 111.54
rl894 n351__clk1pt6g n352__clk1pt6g 111.54
rl895 n176__clk100m n177__clk100m 71.1559
rl896 n78__clk100m_b n79__clk100m_b 69.2328
rl897 n79__clk100m_b n80__clk100m_b 111.54
rl898 n81__clk100m_b n82__clk100m_b 113.464
rl899 n81__clk100m_b n83__clk100m_b 126.923
rl900 i28__net14 n2__i28__net14 53.7308
rl901 n2__i28__net14 n3__i28__net14 37.2834
rl902 n3__i28__net14 n4__i28__net14 106.321
rl903 n4__i28__net14 n5__i28__net14 76.5385
rl904 n5__i28__net14 n6__i28__net14 76.5385
rl905 n6__i28__net14 n7__i28__net14 76.5385
rl906 n7__i28__net14 n8__i28__net14 76.5385
rl907 n8__i28__net14 n9__i28__net14 76.5385
rl908 n9__i28__net14 n10__i28__net14 76.5385
rl909 n10__i28__net14 n11__i28__net14 76.5385
rl910 n11__i28__net14 n12__i28__net14 76.5385
rl911 n12__i28__net14 n13__i28__net14 76.5385
rl912 n13__i28__net14 n14__i28__net14 76.5385
rl913 n14__i28__net14 n15__i28__net14 76.5385
rl914 n15__i28__net14 n16__i28__net14 76.5385
rl915 n16__i28__net14 n17__i28__net14 76.5385
rl916 n17__i28__net14 n18__i28__net14 106.321
rl917 n18__i28__net14 n19__i28__net14 40.1923
rl918 n19__i28__net14 n20__i28__net14 42.1154
rl919 n20__i28__net14 n21__i28__net14 98.0548
rl920 n21__i28__net14 n22__i28__net14 22.7584
rl921 n22__i28__net14 n23__i28__net14 40.0202
rl922 n23__i28__net14 n24__i28__net14 38.0971
rl923 n24__i28__net14 n25__i28__net14 12.5
rl924 n23__i28__net14 n26__i28__net14 32.0714
rl925 n23__i28__net14 n27__i28__net14 72.348
rl926 n27__i28__net14 n28__i28__net14 38.0971
rl927 n28__i28__net14 n29__i28__net14 12.5
rl928 n25__i28__net14 n17__i28__net14 13.8175
rl929 n26__i28__net14 n19__i28__net14 27.9842
rl930 n27__i28__net14 n30__i28__net14 40.0202
rl931 n30__i28__net14 n31__i28__net14 22.7584
rl932 n31__i28__net14 n32__i28__net14 33.5925
rl933 n29__i28__net14 n16__i28__net14 13.8175
rl934 n31__i28__net14 n33__i28__net14 75.3901
rl935 n33__i28__net14 n34__i28__net14 22.7584
rl936 n34__i28__net14 n35__i28__net14 40.0202
rl937 n35__i28__net14 n36__i28__net14 38.0971
rl938 n36__i28__net14 n37__i28__net14 12.5
rl939 n32__i28__net14 n21__i28__net14 33.5925
rl940 n35__i28__net14 n38__i28__net14 32.0714
rl941 n35__i28__net14 n39__i28__net14 72.348
rl942 n39__i28__net14 n40__i28__net14 38.0971
rl943 n40__i28__net14 n41__i28__net14 12.5
rl944 n37__i28__net14 n15__i28__net14 13.8175
rl945 n38__i28__net14 n27__i28__net14 32.0714
rl946 n39__i28__net14 n42__i28__net14 40.0202
rl947 n42__i28__net14 n43__i28__net14 22.7584
rl948 n43__i28__net14 n44__i28__net14 33.5925
rl949 n41__i28__net14 n14__i28__net14 13.8175
rl950 n43__i28__net14 n45__i28__net14 75.3901
rl951 n45__i28__net14 n46__i28__net14 22.7584
rl952 n46__i28__net14 n47__i28__net14 40.0202
rl953 n47__i28__net14 n48__i28__net14 38.0971
rl954 n48__i28__net14 n49__i28__net14 12.5
rl955 n44__i28__net14 n33__i28__net14 33.5925
rl956 n47__i28__net14 n50__i28__net14 32.0714
rl957 n47__i28__net14 n51__i28__net14 72.348
rl958 n51__i28__net14 n52__i28__net14 38.0971
rl959 n52__i28__net14 n53__i28__net14 12.5
rl960 n49__i28__net14 n13__i28__net14 13.8175
rl961 n50__i28__net14 n39__i28__net14 32.0714
rl962 n51__i28__net14 n54__i28__net14 40.0202
rl963 n54__i28__net14 n55__i28__net14 22.7584
rl964 n55__i28__net14 n56__i28__net14 33.5925
rl965 n53__i28__net14 n12__i28__net14 13.8175
rl966 n55__i28__net14 n57__i28__net14 75.3901
rl967 n57__i28__net14 n58__i28__net14 22.7584
rl968 n58__i28__net14 n59__i28__net14 40.0202
rl969 n59__i28__net14 n60__i28__net14 38.0971
rl970 n60__i28__net14 n61__i28__net14 12.5
rl971 n56__i28__net14 n45__i28__net14 33.5925
rl972 n59__i28__net14 n62__i28__net14 32.0714
rl973 n59__i28__net14 n63__i28__net14 72.348
rl974 n63__i28__net14 n64__i28__net14 38.0971
rl975 n64__i28__net14 n65__i28__net14 12.5
rl976 n61__i28__net14 n11__i28__net14 13.8175
rl977 n62__i28__net14 n51__i28__net14 32.0714
rl978 n63__i28__net14 n66__i28__net14 40.0202
rl979 n66__i28__net14 n67__i28__net14 22.7584
rl980 n67__i28__net14 n68__i28__net14 33.5925
rl981 n65__i28__net14 n10__i28__net14 13.8175
rl982 n67__i28__net14 n69__i28__net14 75.3901
rl983 n69__i28__net14 n70__i28__net14 22.7584
rl984 n70__i28__net14 n71__i28__net14 40.0202
rl985 n71__i28__net14 n72__i28__net14 38.0971
rl986 n72__i28__net14 n73__i28__net14 12.5
rl987 n68__i28__net14 n57__i28__net14 33.5925
rl988 n71__i28__net14 n74__i28__net14 32.0714
rl989 n71__i28__net14 n75__i28__net14 72.348
rl990 n75__i28__net14 n76__i28__net14 38.0971
rl991 n76__i28__net14 n77__i28__net14 12.5
rl992 n73__i28__net14 n9__i28__net14 13.8175
rl993 n74__i28__net14 n63__i28__net14 32.0714
rl994 n75__i28__net14 n78__i28__net14 40.0202
rl995 n78__i28__net14 n79__i28__net14 22.7584
rl996 n79__i28__net14 n80__i28__net14 33.5925
rl997 n77__i28__net14 n8__i28__net14 13.8175
rl998 n79__i28__net14 n81__i28__net14 75.3901
rl999 n81__i28__net14 n82__i28__net14 22.7584
rl1000 n82__i28__net14 n83__i28__net14 40.0202
rl1001 n83__i28__net14 n84__i28__net14 38.0971
rl1002 n84__i28__net14 n85__i28__net14 12.5
rl1003 n80__i28__net14 n69__i28__net14 33.5925
rl1004 n83__i28__net14 n86__i28__net14 32.0714
rl1005 n83__i28__net14 n87__i28__net14 72.348
rl1006 n87__i28__net14 n88__i28__net14 38.0971
rl1007 n88__i28__net14 n89__i28__net14 12.5
rl1008 n85__i28__net14 n7__i28__net14 13.8175
rl1009 n86__i28__net14 n75__i28__net14 32.0714
rl1010 n87__i28__net14 n90__i28__net14 40.0202
rl1011 n90__i28__net14 n91__i28__net14 22.7584
rl1012 n91__i28__net14 n92__i28__net14 33.5925
rl1013 n89__i28__net14 n6__i28__net14 13.8175
rl1014 n91__i28__net14 n93__i28__net14 75.3901
rl1015 n93__i28__net14 n94__i28__net14 22.7584
rl1016 n94__i28__net14 n95__i28__net14 40.0202
rl1017 n95__i28__net14 n96__i28__net14 38.0971
rl1018 n96__i28__net14 n97__i28__net14 12.5
rl1019 n92__i28__net14 n81__i28__net14 33.5925
rl1020 n95__i28__net14 n98__i28__net14 32.0714
rl1021 n95__i28__net14 n99__i28__net14 72.348
rl1022 n99__i28__net14 n100__i28__net14 38.0971
rl1023 n100__i28__net14 n101__i28__net14 12.5
rl1024 n97__i28__net14 n5__i28__net14 13.8175
rl1025 n98__i28__net14 n87__i28__net14 32.0714
rl1026 n99__i28__net14 n102__i28__net14 40.0202
rl1027 n102__i28__net14 n103__i28__net14 22.7584
rl1028 n103__i28__net14 n104__i28__net14 33.5925
rl1029 n99__i28__net14 n105__i28__net14 32.0714
rl1030 n101__i28__net14 n4__i28__net14 13.8175
rl1031 n103__i28__net14 n106__i28__net14 98.0548
rl1032 n106__i28__net14 n107__i28__net14 10
rl1033 n104__i28__net14 n93__i28__net14 33.5925
rl1034 n105__i28__net14 n2__i28__net14 32.9951
rl1035 n107__i28__net14 n2__i28__net14 24.2065
rl1036 i40__i52__x n2__i40__i52__x 35.7713
rl1037 n2__i40__i52__x n3__i40__i52__x 37.6944
rl1038 i28__net3 n2__i28__net3 149.81
rl1039 n2__i28__net3 n3__i28__net3 28.6538
rl1040 n3__i28__net3 n4__i28__net3 40.0202
rl1041 n4__i28__net3 n5__i28__net3 38.0971
rl1042 n5__i28__net3 n6__i28__net3 120.719
rl1043 n6__i28__net3 n7__i28__net3 28.079
rl1044 n4__i28__net3 n8__i28__net3 156.963
rl1045 n8__i28__net3 n9__i28__net3 38.0971
rl1046 n9__i28__net3 n10__i28__net3 120.719
rl1047 n10__i28__net3 n11__i28__net3 40.1923
rl1048 n11__i28__net3 n12__i28__net3 27.9842
rl1049 n7__i28__net3 n13__i28__net3 28.079
rl1050 n13__i28__net3 n14__i28__net3 56.2572
rl1051 n7__i28__net3 n15__i28__net3 34.6687
rl1052 n11__i28__net3 n16__i28__net3 42.1154
rl1053 n16__i28__net3 n17__i28__net3 120.719
rl1054 n17__i28__net3 n18__i28__net3 15
rl1055 n12__i28__net3 n8__i28__net3 32.0714
rl1056 n14__i28__net3 n2__i28__net3 27.9842
rl1057 n15__i28__net3 n4__i28__net3 32.0714
rl1058 n18__i28__net3 n8__i28__net3 20.4048
rl1059 n74__rst n75__rst 38.1757
rl1060 n75__rst n76__rst 49.3144
rl1061 n75__rst n77__rst 80.4834
rl1062 n77__rst n78__rst 111.54
rl1063 n180__clk100m n181__clk100m 126.923
rl1064 n181__clk100m n182__clk100m 69.2328
rl1065 i29__i135__x n2__i29__i135__x 99.7141
rl1066 n2__i29__i135__x n3__i29__i135__x 50.1123
rl1067 n2__i29__i135__x n4__i29__i135__x 65.0987
rl1068 n45__rst_b n46__rst_b 126.923
rl1069 n46__rst_b n47__rst_b 69.2328
rl1070 i33__i30__x n2__i33__i30__x 99.7141
rl1071 n2__i33__i30__x n3__i33__i30__x 50.1123
rl1072 n2__i33__i30__x n4__i33__i30__x 65.0987
rl1073 n361__clk1pt6g n362__clk1pt6g 111.54
rl1074 n46__net29 n47__net29 111.54
rl1075 n66__net23 n67__net23 71.1559
rl1076 n363__clk1pt6g n364__clk1pt6g 69.2328
rl1077 n364__clk1pt6g n365__clk1pt6g 111.54
rl1078 n85__clk100m_b n86__clk100m_b 71.1559
rl1079 n187__clk100m n188__clk100m 69.2328
rl1080 n188__clk100m n189__clk100m 111.54
rl1081 n1__out6 n2__out6 50.1171
rl1082 n2__out6 n3__out6 40.0987
rl1083 n2__out6 n4__out6 53.5603
rl1084 i28__net17 n2__i28__net17 69.0385
rl1085 n2__i28__net17 n3__i28__net17 70.9615
rl1086 n3__i28__net17 n4__i28__net17 120.719
rl1087 n4__i28__net17 n5__i28__net17 56.9251
rl1088 n5__i28__net17 n6__i28__net17 56.9251
rl1089 n6__i28__net17 n7__i28__net17 108.732
rl1090 n5__i28__net17 n8__i28__net17 33.1687
rl1091 n7__i28__net17 i28__net17 9.1667
rl1092 n8__i28__net17 n2__i28__net17 27.9842
rl1093 i29__net22 n2__i29__net22 334.618
rl1094 i29__net22 n3__i29__net22 173.077
rl1095 n22__en_b n23__en_b 203.848
rl1096 n22__en_b n24__en_b 126.923
rl1097 i33__i20__net1 n2__i33__i20__net1 72.3097
rl1098 n2__i33__i20__net1 n3__i33__i20__net1 72.3097
rl1099 n368__clk1pt6g n369__clk1pt6g 71.1559
rl1100 n71__net23 n72__net23 69.2328
rl1101 n72__net23 n73__net23 111.54
rl1102 n22__en n23__en 157.694
rl1103 n22__en n24__en 126.923
rl1104 n48__net29 n49__net29 111.54
rl1105 n370__clk1pt6g n371__clk1pt6g 111.54
rl1106 n191__clk100m n192__clk100m 71.1559
rl1107 n92__clk100m_b n93__clk100m_b 69.2328
rl1108 n93__clk100m_b n94__clk100m_b 111.54
rl1109 n95__clk100m_b n96__clk100m_b 113.464
rl1110 n95__clk100m_b n97__clk100m_b 126.923
rl1111 i40__i51__x n2__i40__i51__x 35.7713
rl1112 n2__i40__i51__x n3__i40__i51__x 37.6944
rl1113 n90__rst n91__rst 38.1757
rl1114 n91__rst n92__rst 49.3144
rl1115 n91__rst n93__rst 80.4834
rl1116 n93__rst n94__rst 111.54
rl1117 i28__net23 n2__i28__net23 125.643
rl1118 n2__i28__net23 n3__i28__net23 27.5641
rl1119 n3__i28__net23 n4__i28__net23 23.7402
rl1120 n4__i28__net23 n5__i28__net23 51.6011
rl1121 n4__i28__net23 n6__i28__net23 97.6734
rl1122 n6__i28__net23 n7__i28__net23 51.6131
rl1123 n7__i28__net23 n2__i28__net23 24.6956
rl1124 n19__i28__net3 n20__i28__net3 120.719
rl1125 n20__i28__net3 n21__i28__net3 25.7494
rl1126 n21__i28__net3 n22__i28__net3 51.4019
rl1127 n21__i28__net3 n23__i28__net3 88.6921
rl1128 n23__i28__net3 n19__i28__net3 9.1667
rl1129 n195__clk100m n196__clk100m 126.923
rl1130 n196__clk100m n197__clk100m 69.2328
rl1131 i29__i136__x n2__i29__i136__x 99.7141
rl1132 n2__i29__i136__x n3__i29__i136__x 50.1123
rl1133 n2__i29__i136__x n4__i29__i136__x 65.0987
rl1134 n55__rst_b n56__rst_b 126.923
rl1135 n56__rst_b n57__rst_b 69.2328
rl1136 i33__i20__x n2__i33__i20__x 99.7141
rl1137 n2__i33__i20__x n3__i33__i20__x 50.1123
rl1138 n2__i33__i20__x n4__i33__i20__x 65.0987
rl1139 n380__clk1pt6g n381__clk1pt6g 111.54
rl1140 n55__net29 n56__net29 111.54
rl1141 n75__net23 n76__net23 71.1559
rl1142 n382__clk1pt6g n383__clk1pt6g 69.2328
rl1143 n383__clk1pt6g n384__clk1pt6g 111.54
rl1144 n123__clk100m_b n124__clk100m_b 71.1559
rl1145 n204__clk100m n205__clk100m 69.2328
rl1146 n205__clk100m n206__clk100m 111.54
rl1147 i28__net10 n2__i28__net10 51.3851
rl1148 n2__i28__net10 n3__i28__net10 35.3603
rl1149 n3__i28__net10 n4__i28__net10 106.321
rl1150 n4__i28__net10 n5__i28__net10 76.5385
rl1151 n5__i28__net10 n6__i28__net10 76.5385
rl1152 n6__i28__net10 n7__i28__net10 76.5385
rl1153 n7__i28__net10 n8__i28__net10 76.5385
rl1154 n8__i28__net10 n9__i28__net10 76.5385
rl1155 n9__i28__net10 n10__i28__net10 106.321
rl1156 n10__i28__net10 n11__i28__net10 40.1923
rl1157 n11__i28__net10 n12__i28__net10 42.1154
rl1158 n12__i28__net10 n13__i28__net10 98.0548
rl1159 n13__i28__net10 n14__i28__net10 22.7584
rl1160 n14__i28__net10 n15__i28__net10 40.0202
rl1161 n15__i28__net10 n16__i28__net10 38.0971
rl1162 n16__i28__net10 n17__i28__net10 12.5
rl1163 n15__i28__net10 n18__i28__net10 32.0714
rl1164 n15__i28__net10 n19__i28__net10 72.348
rl1165 n19__i28__net10 n20__i28__net10 38.0971
rl1166 n20__i28__net10 n21__i28__net10 12.5
rl1167 n17__i28__net10 n9__i28__net10 13.8175
rl1168 n18__i28__net10 n11__i28__net10 27.9842
rl1169 n19__i28__net10 n22__i28__net10 40.0202
rl1170 n22__i28__net10 n23__i28__net10 22.7584
rl1171 n23__i28__net10 n24__i28__net10 33.5925
rl1172 n21__i28__net10 n8__i28__net10 13.8175
rl1173 n23__i28__net10 n25__i28__net10 75.3901
rl1174 n25__i28__net10 n26__i28__net10 22.7584
rl1175 n26__i28__net10 n27__i28__net10 40.0202
rl1176 n27__i28__net10 n28__i28__net10 38.0971
rl1177 n28__i28__net10 n29__i28__net10 12.5
rl1178 n24__i28__net10 n13__i28__net10 33.5925
rl1179 n27__i28__net10 n30__i28__net10 32.0714
rl1180 n27__i28__net10 n31__i28__net10 72.348
rl1181 n31__i28__net10 n32__i28__net10 38.0971
rl1182 n32__i28__net10 n33__i28__net10 12.5
rl1183 n29__i28__net10 n7__i28__net10 13.8175
rl1184 n30__i28__net10 n19__i28__net10 32.0714
rl1185 n31__i28__net10 n34__i28__net10 40.0202
rl1186 n34__i28__net10 n35__i28__net10 22.7584
rl1187 n35__i28__net10 n36__i28__net10 33.5925
rl1188 n33__i28__net10 n6__i28__net10 13.8175
rl1189 n35__i28__net10 n37__i28__net10 75.3901
rl1190 n37__i28__net10 n38__i28__net10 22.7584
rl1191 n38__i28__net10 n39__i28__net10 40.0202
rl1192 n39__i28__net10 n40__i28__net10 38.0971
rl1193 n40__i28__net10 n41__i28__net10 12.5
rl1194 n36__i28__net10 n25__i28__net10 33.5925
rl1195 n39__i28__net10 n42__i28__net10 32.0714
rl1196 n39__i28__net10 n43__i28__net10 72.348
rl1197 n43__i28__net10 n44__i28__net10 38.0971
rl1198 n44__i28__net10 n45__i28__net10 12.5
rl1199 n41__i28__net10 n5__i28__net10 13.8175
rl1200 n42__i28__net10 n31__i28__net10 32.0714
rl1201 n43__i28__net10 n46__i28__net10 40.0202
rl1202 n46__i28__net10 n47__i28__net10 22.7584
rl1203 n47__i28__net10 n48__i28__net10 33.5925
rl1204 n43__i28__net10 n49__i28__net10 32.0714
rl1205 n45__i28__net10 n4__i28__net10 13.8175
rl1206 n47__i28__net10 n50__i28__net10 98.0548
rl1207 n50__i28__net10 n51__i28__net10 10.8333
rl1208 n48__i28__net10 n37__i28__net10 33.5925
rl1209 n49__i28__net10 n2__i28__net10 32.9951
rl1210 n51__i28__net10 n2__i28__net10 25.0398
rl1211 n1__out7 n2__out7 50.1171
rl1212 n2__out7 n3__out7 40.0987
rl1213 n2__out7 n4__out7 53.5603
rl1214 i28__i71__x n2__i28__i71__x 67.1154
rl1215 n2__i28__i71__x n3__i28__i71__x 72.8846
rl1216 n3__i28__i71__x n4__i28__i71__x 120.719
rl1217 n4__i28__i71__x n5__i28__i71__x 60.7713
rl1218 n5__i28__i71__x n6__i28__i71__x 53.079
rl1219 n6__i28__i71__x n7__i28__i71__x 108.732
rl1220 n5__i28__i71__x n8__i28__i71__x 33.1687
rl1221 n7__i28__i71__x i28__i71__x 9.1667
rl1222 n8__i28__i71__x n2__i28__i71__x 27.9842
rl1223 i29__net15 n2__i29__net15 334.618
rl1224 i29__net15 n3__i29__net15 173.077
rl1225 n25__en_b n26__en_b 203.848
rl1226 n25__en_b n27__en_b 126.923
rl1227 i33__i21__net1 n2__i33__i21__net1 72.3097
rl1228 n2__i33__i21__net1 n3__i33__i21__net1 72.3097
rl1229 n387__clk1pt6g n388__clk1pt6g 71.1559
rl1230 n80__net23 n81__net23 69.2328
rl1231 n81__net23 n82__net23 111.54
rl1232 n25__en n26__en 157.694
rl1233 n25__en n27__en 126.923
rl1234 n57__net29 n58__net29 111.54
rl1235 n389__clk1pt6g n390__clk1pt6g 111.54
rl1236 n208__clk100m n209__clk100m 71.1559
rl1237 n130__clk100m_b n131__clk100m_b 69.2328
rl1238 n131__clk100m_b n132__clk100m_b 111.54
rl1239 n133__clk100m_b n134__clk100m_b 113.464
rl1240 n133__clk100m_b n135__clk100m_b 126.923
rl1241 i28__net4 n2__i28__net4 53.7308
rl1242 n2__i28__net4 n3__i28__net4 35.3603
rl1243 n3__i28__net4 n4__i28__net4 120.719
rl1244 n4__i28__net4 n5__i28__net4 40.1923
rl1245 n5__i28__net4 n6__i28__net4 42.1154
rl1246 n6__i28__net4 n7__i28__net4 120.719
rl1247 n7__i28__net4 n8__i28__net4 10.8333
rl1248 n5__i28__net4 n9__i28__net4 27.9842
rl1249 n8__i28__net4 n2__i28__net4 25.0398
rl1250 n9__i28__net4 n2__i28__net4 32.9951
rl1251 i40__i50__x n2__i40__i50__x 35.7713
rl1252 n2__i40__i50__x n3__i40__i50__x 37.6944
rl1253 n24__i28__net3 n25__i28__net3 97.2539
rl1254 n25__i28__net3 n26__i28__net3 51.9794
rl1255 n25__i28__net3 n27__i28__net3 24.2362
rl1256 n27__i28__net3 n28__i28__net3 26.6591
rl1257 n28__i28__net3 n29__i28__net3 124.968
rl1258 n28__i28__net3 n30__i28__net3 70.9249
rl1259 n30__i28__net3 n24__i28__net3 8.3333
rl1260 n8__i28__net23 n9__i28__net23 109.826
rl1261 n9__i28__net23 n10__i28__net23 25.7494
rl1262 n10__i28__net23 n11__i28__net23 51.4019
rl1263 n10__i28__net23 n12__i28__net23 88.6921
rl1264 n12__i28__net23 n8__i28__net23 9.1667
rl1265 n106__rst n107__rst 38.1757
rl1266 n107__rst n108__rst 49.3144
rl1267 n107__rst n109__rst 80.4834
rl1268 n109__rst n110__rst 111.54
rl1269 n212__clk100m n213__clk100m 126.923
rl1270 n213__clk100m n214__clk100m 69.2328
rl1271 i29__i137__x n2__i29__i137__x 99.7141
rl1272 n2__i29__i137__x n3__i29__i137__x 50.1123
rl1273 n2__i29__i137__x n4__i29__i137__x 65.0987
rl1274 n65__rst_b n66__rst_b 126.923
rl1275 n66__rst_b n67__rst_b 69.2328
rl1276 i33__i21__x n2__i33__i21__x 99.7141
rl1277 n2__i33__i21__x n3__i33__i21__x 50.1123
rl1278 n2__i33__i21__x n4__i33__i21__x 65.0987
rl1279 n399__clk1pt6g n400__clk1pt6g 111.54
rl1280 n64__net29 n65__net29 111.54
rl1281 n84__net23 n85__net23 71.1559
rl1282 n401__clk1pt6g n402__clk1pt6g 69.2328
rl1283 n402__clk1pt6g n403__clk1pt6g 111.54
rl1284 n137__clk100m_b n138__clk100m_b 71.1559
rl1285 n219__clk100m n220__clk100m 69.2328
rl1286 n220__clk100m n221__clk100m 111.54
rl1287 i28__net2 n2__i28__net2 61.7095
rl1288 n2__i28__net2 n3__i28__net2 35.3603
rl1289 n3__i28__net2 n4__i28__net2 120.719
rl1290 n4__i28__net2 n5__i28__net2 40.1923
rl1291 n5__i28__net2 n6__i28__net2 42.1154
rl1292 n6__i28__net2 n7__i28__net2 120.719
rl1293 n7__i28__net2 n8__i28__net2 10.8333
rl1294 n5__i28__net2 n9__i28__net2 27.9842
rl1295 n8__i28__net2 n2__i28__net2 25.0398
rl1296 n9__i28__net2 n2__i28__net2 32.9951
rl1297 n1__out8 n2__out8 50.1171
rl1298 n2__out8 n3__out8 40.0987
rl1299 n2__out8 n4__out8 53.5603
rl1300 i29__net31 n2__i29__net31 334.618
rl1301 i29__net31 n3__i29__net31 173.077
rl1302 n28__en_b n29__en_b 203.848
rl1303 n28__en_b n30__en_b 126.923
rl1304 i33__i19__net1 n2__i33__i19__net1 72.3097
rl1305 n2__i33__i19__net1 n3__i33__i19__net1 72.3097
rl1306 n406__clk1pt6g n407__clk1pt6g 71.1559
rl1307 n89__net23 n90__net23 69.2328
rl1308 n90__net23 n91__net23 111.54
rl1309 n28__en n29__en 157.694
rl1310 n28__en n30__en 126.923
rl1311 n66__net29 n67__net29 111.54
rl1312 n408__clk1pt6g n409__clk1pt6g 111.54
rl1313 n223__clk100m n224__clk100m 71.1559
rl1314 n144__clk100m_b n145__clk100m_b 69.2328
rl1315 n145__clk100m_b n146__clk100m_b 111.54
rl1316 n147__clk100m_b n148__clk100m_b 113.464
rl1317 n147__clk100m_b n149__clk100m_b 126.923
rl1318 i28__i50__net1 n2__i28__i50__net1 37.2721
rl1319 n2__i28__i50__net1 n3__i28__i50__net1 38.1353
rl1320 i28__net12 n2__i28__net12 149.81
rl1321 n2__i28__net12 n3__i28__net12 28.6538
rl1322 n3__i28__net12 n4__i28__net12 40.0202
rl1323 n4__i28__net12 n5__i28__net12 38.0971
rl1324 n5__i28__net12 n6__i28__net12 120.719
rl1325 n6__i28__net12 n7__i28__net12 28.079
rl1326 n4__i28__net12 n8__i28__net12 156.963
rl1327 n8__i28__net12 n9__i28__net12 38.0971
rl1328 n9__i28__net12 n10__i28__net12 120.719
rl1329 n10__i28__net12 n11__i28__net12 40.1923
rl1330 n11__i28__net12 n12__i28__net12 27.9842
rl1331 n7__i28__net12 n13__i28__net12 28.079
rl1332 n13__i28__net12 n14__i28__net12 56.2572
rl1333 n7__i28__net12 n15__i28__net12 34.6687
rl1334 n11__i28__net12 n16__i28__net12 42.1154
rl1335 n16__i28__net12 n17__i28__net12 120.719
rl1336 n17__i28__net12 n18__i28__net12 15
rl1337 n12__i28__net12 n8__i28__net12 32.0714
rl1338 n14__i28__net12 n2__i28__net12 27.9842
rl1339 n15__i28__net12 n4__i28__net12 32.0714
rl1340 n18__i28__net12 n8__i28__net12 20.4048
rl1341 i40__i49__x n2__i40__i49__x 35.7713
rl1342 n2__i40__i49__x n3__i40__i49__x 37.6944
rl1343 n122__rst n123__rst 38.1757
rl1344 n123__rst n124__rst 49.3144
rl1345 n123__rst n125__rst 80.4834
rl1346 n125__rst n126__rst 111.54
rl1347 n227__clk100m n228__clk100m 126.923
rl1348 n228__clk100m n229__clk100m 69.2328
rl1349 i29__i138__x n2__i29__i138__x 99.7141
rl1350 n2__i29__i138__x n3__i29__i138__x 50.1123
rl1351 n2__i29__i138__x n4__i29__i138__x 65.0987
rl1352 n75__rst_b n76__rst_b 126.923
rl1353 n76__rst_b n77__rst_b 69.2328
rl1354 i33__i19__x n2__i33__i19__x 99.7141
rl1355 n2__i33__i19__x n3__i33__i19__x 50.1123
rl1356 n2__i33__i19__x n4__i33__i19__x 65.0987
rl1357 n418__clk1pt6g n419__clk1pt6g 111.54
rl1358 n73__net29 n74__net29 111.54
rl1359 n93__net23 n94__net23 71.1559
rl1360 n420__clk1pt6g n421__clk1pt6g 69.2328
rl1361 n421__clk1pt6g n422__clk1pt6g 111.54
rl1362 n151__clk100m_b n152__clk100m_b 71.1559
rl1363 n234__clk100m n235__clk100m 69.2328
rl1364 n235__clk100m n236__clk100m 111.54
rl1365 n4__i28__i50__net1 n5__i28__i50__net1 37.2721
rl1366 n5__i28__i50__net1 n6__i28__i50__net1 38.1353
rl1367 n1__out9 n2__out9 50.1171
rl1368 n2__out9 n3__out9 40.0987
rl1369 n2__out9 n4__out9 53.5603
rl1370 i28__net19 n2__i28__net19 69.0385
rl1371 n2__i28__net19 n3__i28__net19 70.9615
rl1372 n3__i28__net19 n4__i28__net19 120.719
rl1373 n4__i28__net19 n5__i28__net19 56.9251
rl1374 n5__i28__net19 n6__i28__net19 56.9251
rl1375 n6__i28__net19 n7__i28__net19 108.732
rl1376 n5__i28__net19 n8__i28__net19 33.1687
rl1377 n7__i28__net19 i28__net19 9.1667
rl1378 n8__i28__net19 n2__i28__net19 27.9842
rl1379 i29__net11 n2__i29__net11 334.618
rl1380 i29__net11 n3__i29__net11 173.077
rl1381 n31__en_b n32__en_b 203.848
rl1382 n31__en_b n33__en_b 126.923
rl1383 i33__i22__net1 n2__i33__i22__net1 72.3097
rl1384 n2__i33__i22__net1 n3__i33__i22__net1 72.3097
rl1385 n425__clk1pt6g n426__clk1pt6g 71.1559
rl1386 n98__net23 n99__net23 69.2328
rl1387 n99__net23 n100__net23 111.54
rl1388 n31__en n32__en 157.694
rl1389 n31__en n33__en 126.923
rl1390 n75__net29 n76__net29 111.54
rl1391 n427__clk1pt6g n428__clk1pt6g 111.54
rl1392 n262__clk100m n263__clk100m 71.1559
rl1393 n158__clk100m_b n159__clk100m_b 69.2328
rl1394 n159__clk100m_b n160__clk100m_b 111.54
rl1395 n161__clk100m_b n162__clk100m_b 113.464
rl1396 n161__clk100m_b n163__clk100m_b 126.923
rl1397 i40__i48__x n2__i40__i48__x 35.7713
rl1398 n2__i40__i48__x n3__i40__i48__x 37.6944
rl1399 i28__net7 n2__i28__net7 35.5308
rl1400 n2__i28__net7 n3__i28__net7 74.1496
rl1401 n3__i28__net7 n4__i28__net7 39.6181
rl1402 n2__i28__net7 n5__i28__net7 33.5649
rl1403 n3__i28__net7 n6__i28__net7 58.8489
rl1404 n138__rst n139__rst 38.1757
rl1405 n139__rst n140__rst 49.3144
rl1406 n139__rst n141__rst 80.4834
rl1407 n141__rst n142__rst 111.54
rl1408 i28__net26 n2__i28__net26 125.643
rl1409 n2__i28__net26 n3__i28__net26 27.5641
rl1410 n3__i28__net26 n4__i28__net26 23.7402
rl1411 n4__i28__net26 n5__i28__net26 51.6011
rl1412 n4__i28__net26 n6__i28__net26 97.6734
rl1413 n6__i28__net26 n7__i28__net26 51.6131
rl1414 n7__i28__net26 n2__i28__net26 24.6956
rl1415 n19__i28__net12 n20__i28__net12 120.719
rl1416 n20__i28__net12 n21__i28__net12 25.7494
rl1417 n21__i28__net12 n22__i28__net12 51.4019
rl1418 n21__i28__net12 n23__i28__net12 88.6921
rl1419 n23__i28__net12 n19__i28__net12 9.1667
rl1420 n266__clk100m n267__clk100m 126.923
rl1421 n267__clk100m n268__clk100m 69.2328
rl1422 i29__i139__x n2__i29__i139__x 99.7141
rl1423 n2__i29__i139__x n3__i29__i139__x 50.1123
rl1424 n2__i29__i139__x n4__i29__i139__x 65.0987
rl1425 n85__rst_b n86__rst_b 126.923
rl1426 n86__rst_b n87__rst_b 69.2328
rl1427 i33__i22__x n2__i33__i22__x 99.7141
rl1428 n2__i33__i22__x n3__i33__i22__x 50.1123
rl1429 n2__i33__i22__x n4__i33__i22__x 65.0987
rl1430 n437__clk1pt6g n438__clk1pt6g 111.54
rl1431 n82__net29 n83__net29 111.54
rl1432 n102__net23 n103__net23 71.1559
rl1433 n439__clk1pt6g n440__clk1pt6g 69.2328
rl1434 n440__clk1pt6g n441__clk1pt6g 111.54
rl1435 n165__clk100m_b n166__clk100m_b 71.1559
rl1436 n273__clk100m n274__clk100m 69.2328
rl1437 n274__clk100m n275__clk100m 111.54
rl1438 i28__net8 n2__i28__net8 63.143
rl1439 n2__i28__net8 n3__i28__net8 402.313
rl1440 n3__i28__net8 n4__i28__net8 63.143
rl1441 n4__i28__net8 n5__i28__net8 40.1923
rl1442 n5__i28__net8 n6__i28__net8 59.4231
rl1443 n6__i28__net8 n7__i28__net8 82.3738
rl1444 n7__i28__net8 n8__i28__net8 644.621
rl1445 n8__i28__net8 n9__i28__net8 157.67
rl1446 n2__i28__net8 n10__i28__net8 138.439
rl1447 n7__i28__net8 n11__i28__net8 157.67
rl1448 n11__i28__net8 n12__i28__net8 45.3867
rl1449 n12__i28__net8 n13__i28__net8 28.079
rl1450 n13__i28__net8 n14__i28__net8 96.6418
rl1451 n8__i28__net8 n15__i28__net8 82.3738
rl1452 n12__i28__net8 n16__i28__net8 34.6687
rl1453 n14__i28__net8 n3__i28__net8 33.5925
rl1454 n16__i28__net8 n5__i28__net8 27.9842
rl1455 i28__i72__x n2__i28__i72__x 67.1154
rl1456 n2__i28__i72__x n3__i28__i72__x 72.8846
rl1457 n3__i28__i72__x n4__i28__i72__x 120.719
rl1458 n4__i28__i72__x n5__i28__i72__x 60.7713
rl1459 n5__i28__i72__x n6__i28__i72__x 53.079
rl1460 n6__i28__i72__x n7__i28__i72__x 108.732
rl1461 n5__i28__i72__x n8__i28__i72__x 33.1687
rl1462 n7__i28__i72__x i28__i72__x 9.1667
rl1463 n8__i28__i72__x n2__i28__i72__x 27.9842
rl1464 n1__out10 n2__out10 50.1171
rl1465 n2__out10 n3__out10 40.0987
rl1466 n2__out10 n4__out10 53.5603
rl1467 i29__net5 n2__i29__net5 334.618
rl1468 i29__net5 n3__i29__net5 173.077
rl1469 n34__en_b n35__en_b 203.848
rl1470 n34__en_b n36__en_b 126.923
rl1471 i33__i17__net1 n2__i33__i17__net1 72.3097
rl1472 n2__i33__i17__net1 n3__i33__i17__net1 72.3097
rl1473 n444__clk1pt6g n445__clk1pt6g 71.1559
rl1474 n107__net23 n108__net23 69.2328
rl1475 n108__net23 n109__net23 111.54
rl1476 n34__en n35__en 157.694
rl1477 n34__en n36__en 126.923
rl1478 n84__net29 n85__net29 111.54
rl1479 n446__clk1pt6g n447__clk1pt6g 111.54
rl1480 n277__clk100m n278__clk100m 71.1559
rl1481 n172__clk100m_b n173__clk100m_b 69.2328
rl1482 n173__clk100m_b n174__clk100m_b 111.54
rl1483 n175__clk100m_b n176__clk100m_b 113.464
rl1484 n175__clk100m_b n177__clk100m_b 126.923
rl1485 i40__i47__x n2__i40__i47__x 35.7713
rl1486 n2__i40__i47__x n3__i40__i47__x 37.6944
rl1487 n24__i28__net12 n25__i28__net12 125.643
rl1488 n25__i28__net12 n26__i28__net12 27.5641
rl1489 n26__i28__net12 n27__i28__net12 23.7402
rl1490 n27__i28__net12 n28__i28__net12 51.6011
rl1491 n27__i28__net12 n29__i28__net12 97.6734
rl1492 n29__i28__net12 n30__i28__net12 51.6131
rl1493 n30__i28__net12 n25__i28__net12 24.6956
rl1494 n8__i28__net26 n9__i28__net26 109.826
rl1495 n9__i28__net26 n10__i28__net26 25.7494
rl1496 n10__i28__net26 n11__i28__net26 51.4019
rl1497 n10__i28__net26 n12__i28__net26 88.6921
rl1498 n12__i28__net26 n8__i28__net26 9.1667
rl1499 n45__net22 n46__net22 153.313
rl1500 n46__net22 n47__net22 27.5641
rl1501 n47__net22 n48__net22 97.6734
rl1502 n48__net22 n49__net22 23.7402
rl1503 n49__net22 n50__net22 51.6131
rl1504 n48__net22 n51__net22 51.6011
rl1505 n50__net22 n46__net22 24.6956
rl1506 n450__clk1pt6g n451__clk1pt6g 51.4019
rl1507 n451__clk1pt6g n452__clk1pt6g 25.7494
rl1508 n452__clk1pt6g n453__clk1pt6g 109.826
rl1509 n453__clk1pt6g n454__clk1pt6g 56.2572
rl1510 n454__clk1pt6g n451__clk1pt6g 36.217
rl1511 n154__rst n155__rst 38.1757
rl1512 n155__rst n156__rst 49.3144
rl1513 n155__rst n157__rst 80.4834
rl1514 n157__rst n158__rst 111.54
rl1515 n281__clk100m n282__clk100m 126.923
rl1516 n282__clk100m n283__clk100m 69.2328
rl1517 i29__i140__x n2__i29__i140__x 99.7141
rl1518 n2__i29__i140__x n3__i29__i140__x 50.1123
rl1519 n2__i29__i140__x n4__i29__i140__x 65.0987
rl1520 n95__rst_b n96__rst_b 126.923
rl1521 n96__rst_b n97__rst_b 69.2328
rl1522 i33__i17__x n2__i33__i17__x 99.7141
rl1523 n2__i33__i17__x n3__i33__i17__x 50.1123
rl1524 n2__i33__i17__x n4__i33__i17__x 65.0987
rl1525 n461__clk1pt6g n462__clk1pt6g 111.54
rl1526 n91__net29 n92__net29 111.54
rl1527 n111__net23 n112__net23 71.1559
rl1528 n463__clk1pt6g n464__clk1pt6g 69.2328
rl1529 n464__clk1pt6g n465__clk1pt6g 111.54
rl1530 n179__clk100m_b n180__clk100m_b 71.1559
rl1531 n288__clk100m n289__clk100m 69.2328
rl1532 n289__clk100m n290__clk100m 111.54
rl1533 i28__i53__x n2__i28__i53__x 60.7713
rl1534 n2__i28__i53__x n3__i28__i53__x 120.719
rl1535 n3__i28__i53__x n4__i28__i53__x 72.8846
rl1536 n4__i28__i53__x n5__i28__i53__x 67.1154
rl1537 n5__i28__i53__x n6__i28__i53__x 120.719
rl1538 n6__i28__i53__x n7__i28__i53__x 20.8333
rl1539 n4__i28__i53__x n8__i28__i53__x 27.9842
rl1540 n7__i28__i53__x i28__i53__x 25.8354
rl1541 n8__i28__i53__x i28__i53__x 33.1687
rl1542 n1__out11 n2__out11 50.1171
rl1543 n2__out11 n3__out11 40.0987
rl1544 n2__out11 n4__out11 53.5603
rl1545 i29__net1 n2__i29__net1 334.618
rl1546 i29__net1 n3__i29__net1 173.077
rl1547 n37__en_b n38__en_b 203.848
rl1548 n37__en_b n39__en_b 126.923
rl1549 i33__i18__net1 n2__i33__i18__net1 72.3097
rl1550 n2__i33__i18__net1 n3__i33__i18__net1 72.3097
rl1551 n468__clk1pt6g n469__clk1pt6g 71.1559
rl1552 n116__net23 n117__net23 69.2328
rl1553 n117__net23 n118__net23 111.54
rl1554 n37__en n38__en 157.694
rl1555 n37__en n39__en 126.923
rl1556 n93__net29 n94__net29 111.54
rl1557 n470__clk1pt6g n471__clk1pt6g 111.54
rl1558 n292__clk100m n293__clk100m 71.1559
rl1559 n188__clk100m_b n189__clk100m_b 69.2328
rl1560 n189__clk100m_b n190__clk100m_b 111.54
rl1561 n191__clk100m_b n192__clk100m_b 113.464
rl1562 n191__clk100m_b n193__clk100m_b 126.923
rl1563 n474__clk1pt6g n475__clk1pt6g 153.313
rl1564 n475__clk1pt6g n476__clk1pt6g 27.5641
rl1565 n476__clk1pt6g n477__clk1pt6g 97.6734
rl1566 n477__clk1pt6g n478__clk1pt6g 23.7402
rl1567 n478__clk1pt6g n479__clk1pt6g 51.6131
rl1568 n477__clk1pt6g n480__clk1pt6g 51.6011
rl1569 n479__clk1pt6g n475__clk1pt6g 24.6956
rl1570 n52__net22 n53__net22 51.4019
rl1571 n53__net22 n54__net22 25.7494
rl1572 n54__net22 n55__net22 120.719
rl1573 n55__net22 n56__net22 56.2572
rl1574 n56__net22 n53__net22 36.217
rl1575 i28__net13 n2__i28__net13 149.798
rl1576 n2__i28__net13 n3__i28__net13 28.4119
rl1577 n3__i28__net13 n4__i28__net13 40.0202
rl1578 n4__i28__net13 n5__i28__net13 38.0971
rl1579 n5__i28__net13 n6__i28__net13 120.719
rl1580 n6__i28__net13 n7__i28__net13 28.079
rl1581 n4__i28__net13 n8__i28__net13 156.963
rl1582 n8__i28__net13 n9__i28__net13 38.0971
rl1583 n9__i28__net13 n10__i28__net13 120.719
rl1584 n10__i28__net13 n11__i28__net13 40.1923
rl1585 n11__i28__net13 n12__i28__net13 27.9842
rl1586 n7__i28__net13 n13__i28__net13 28.079
rl1587 n13__i28__net13 n14__i28__net13 55.4239
rl1588 n7__i28__net13 n15__i28__net13 34.6687
rl1589 n11__i28__net13 n16__i28__net13 42.1154
rl1590 n16__i28__net13 n17__i28__net13 120.719
rl1591 n17__i28__net13 n18__i28__net13 15
rl1592 n12__i28__net13 n8__i28__net13 32.0714
rl1593 n14__i28__net13 n2__i28__net13 27.3325
rl1594 n15__i28__net13 n4__i28__net13 32.0714
rl1595 n18__i28__net13 n8__i28__net13 20.4048
rl1596 i40__i46__x n2__i40__i46__x 35.7713
rl1597 n2__i40__i46__x n3__i40__i46__x 37.6944
rl1598 n170__rst n171__rst 38.1757
rl1599 n171__rst n172__rst 49.3144
rl1600 n171__rst n173__rst 80.4834
rl1601 n173__rst n174__rst 111.54
rl1602 n296__clk100m n297__clk100m 126.923
rl1603 n297__clk100m n298__clk100m 69.2328
rl1604 i29__i141__x n2__i29__i141__x 99.7141
rl1605 n2__i29__i141__x n3__i29__i141__x 50.1123
rl1606 n2__i29__i141__x n4__i29__i141__x 65.0987
rl1607 n105__rst_b n106__rst_b 126.923
rl1608 n106__rst_b n107__rst_b 69.2328
rl1609 i33__i18__x n2__i33__i18__x 99.7141
rl1610 n2__i33__i18__x n3__i33__i18__x 50.1123
rl1611 n2__i33__i18__x n4__i33__i18__x 65.0987
rl1612 n487__clk1pt6g n488__clk1pt6g 111.54
rl1613 n100__net29 n101__net29 111.54
rl1614 n120__net23 n121__net23 71.1559
rl1615 n489__clk1pt6g n490__clk1pt6g 69.2328
rl1616 n490__clk1pt6g n491__clk1pt6g 111.54
rl1617 n195__clk100m_b n196__clk100m_b 71.1559
rl1618 n304__clk100m n305__clk100m 69.2328
rl1619 n305__clk100m n306__clk100m 111.54
rl1620 n7__i28__net7 n8__i28__net7 56.9251
rl1621 n8__i28__net7 n9__i28__net7 120.719
rl1622 n9__i28__net7 n10__i28__net7 70.9615
rl1623 n10__i28__net7 n11__i28__net7 69.0385
rl1624 n11__i28__net7 n12__i28__net7 120.719
rl1625 n12__i28__net7 n13__i28__net7 22.5
rl1626 n10__i28__net7 n14__i28__net7 27.9842
rl1627 n13__i28__net7 n7__i28__net7 27.5021
rl1628 n14__i28__net7 n7__i28__net7 33.1687
rl1629 n1__out12 n2__out12 50.1171
rl1630 n2__out12 n3__out12 40.0987
rl1631 n2__out12 n4__out12 53.5603
rl1632 i28__net5 n2__i28__net5 69.0385
rl1633 n2__i28__net5 n3__i28__net5 70.9615
rl1634 n3__i28__net5 n4__i28__net5 120.719
rl1635 n4__i28__net5 n5__i28__net5 56.9251
rl1636 n5__i28__net5 n6__i28__net5 56.9251
rl1637 n6__i28__net5 n7__i28__net5 108.732
rl1638 n5__i28__net5 n8__i28__net5 33.1687
rl1639 n7__i28__net5 i28__net5 9.1667
rl1640 n8__i28__net5 n2__i28__net5 27.9842
rl1641 i29__net2 n2__i29__net2 334.618
rl1642 i29__net2 n3__i29__net2 173.077
rl1643 n40__en_b n41__en_b 203.848
rl1644 n40__en_b n42__en_b 126.923
rl1645 i33__i16__net1 n2__i33__i16__net1 72.3097
rl1646 n2__i33__i16__net1 n3__i33__i16__net1 72.3097
rl1647 n494__clk1pt6g n495__clk1pt6g 71.1559
rl1648 n125__net23 n126__net23 69.2328
rl1649 n126__net23 n127__net23 111.54
rl1650 n40__en n41__en 157.694
rl1651 n40__en n42__en 126.923
rl1652 n102__net29 n103__net29 111.54
rl1653 n496__clk1pt6g n497__clk1pt6g 111.54
rl1654 n308__clk100m n309__clk100m 71.1559
rl1655 n202__clk100m_b n203__clk100m_b 69.2328
rl1656 n203__clk100m_b n204__clk100m_b 111.54
rl1657 n205__clk100m_b n206__clk100m_b 113.464
rl1658 n205__clk100m_b n207__clk100m_b 126.923
rl1659 n57__net22 n58__net22 155.198
rl1660 n58__net22 n59__net22 27.2953
rl1661 n59__net22 n60__net22 97.6734
rl1662 n60__net22 n61__net22 23.7402
rl1663 n61__net22 n62__net22 50.8631
rl1664 n60__net22 n63__net22 51.6011
rl1665 n62__net22 n58__net22 24.134
rl1666 n500__clk1pt6g n501__clk1pt6g 51.4019
rl1667 n501__clk1pt6g n502__clk1pt6g 25.7494
rl1668 n502__clk1pt6g n503__clk1pt6g 109.826
rl1669 n503__clk1pt6g n504__clk1pt6g 56.2572
rl1670 n504__clk1pt6g n501__clk1pt6g 36.217
rl1671 i40__i45__x n2__i40__i45__x 35.7713
rl1672 n2__i40__i45__x n3__i40__i45__x 37.6944
rl1673 n186__rst n187__rst 38.1757
rl1674 n187__rst n188__rst 49.3144
rl1675 n187__rst n189__rst 80.4834
rl1676 n189__rst n190__rst 111.54
rl1677 i28__net11 n2__i28__net11 125.643
rl1678 n2__i28__net11 n3__i28__net11 27.5641
rl1679 n3__i28__net11 n4__i28__net11 23.7402
rl1680 n4__i28__net11 n5__i28__net11 51.6011
rl1681 n4__i28__net11 n6__i28__net11 97.6734
rl1682 n6__i28__net11 n7__i28__net11 51.6131
rl1683 n7__i28__net11 n2__i28__net11 24.6956
rl1684 n19__i28__net13 n20__i28__net13 120.719
rl1685 n20__i28__net13 n21__i28__net13 25.7494
rl1686 n21__i28__net13 n22__i28__net13 51.4019
rl1687 n21__i28__net13 n23__i28__net13 88.6921
rl1688 n23__i28__net13 n19__i28__net13 9.1667
rl1689 n312__clk100m n313__clk100m 126.923
rl1690 n313__clk100m n314__clk100m 69.2328
rl1691 i29__i142__x n2__i29__i142__x 99.7141
rl1692 n2__i29__i142__x n3__i29__i142__x 50.1123
rl1693 n2__i29__i142__x n4__i29__i142__x 65.0987
rl1694 n115__rst_b n116__rst_b 126.923
rl1695 n116__rst_b n117__rst_b 69.2328
rl1696 i33__i16__x n2__i33__i16__x 99.7141
rl1697 n2__i33__i16__x n3__i33__i16__x 50.1123
rl1698 n2__i33__i16__x n4__i33__i16__x 65.0987
rl1699 n509__clk1pt6g n510__clk1pt6g 111.54
rl1700 n107__net29 n108__net29 111.54
rl1701 n129__net23 n130__net23 71.1559
rl1702 n511__clk1pt6g n512__clk1pt6g 69.2328
rl1703 n512__clk1pt6g n513__clk1pt6g 111.54
rl1704 n209__clk100m_b n210__clk100m_b 71.1559
rl1705 n319__clk100m n320__clk100m 69.2328
rl1706 n320__clk100m n321__clk100m 111.54
rl1707 i28__i52__x n2__i28__i52__x 60.7713
rl1708 n2__i28__i52__x n3__i28__i52__x 120.719
rl1709 n3__i28__i52__x n4__i28__i52__x 72.8846
rl1710 n4__i28__i52__x n5__i28__i52__x 67.1154
rl1711 n5__i28__i52__x n6__i28__i52__x 120.719
rl1712 n6__i28__i52__x n7__i28__i52__x 20.8333
rl1713 n4__i28__i52__x n8__i28__i52__x 27.9842
rl1714 n7__i28__i52__x i28__i52__x 25.8354
rl1715 n8__i28__i52__x i28__i52__x 33.1687
rl1716 i28__i51__x n2__i28__i51__x 67.1154
rl1717 n2__i28__i51__x n3__i28__i51__x 72.8846
rl1718 n3__i28__i51__x n4__i28__i51__x 120.719
rl1719 n4__i28__i51__x n5__i28__i51__x 60.7713
rl1720 n5__i28__i51__x n6__i28__i51__x 53.079
rl1721 n6__i28__i51__x n7__i28__i51__x 108.732
rl1722 n5__i28__i51__x n8__i28__i51__x 33.1687
rl1723 n7__i28__i51__x i28__i51__x 9.1667
rl1724 n8__i28__i51__x n2__i28__i51__x 27.9842
rl1725 n1__out13 n2__out13 50.1171
rl1726 n2__out13 n3__out13 40.0987
rl1727 n2__out13 n4__out13 53.5603
rl1728 i29__net3 n2__i29__net3 334.618
rl1729 i29__net3 n3__i29__net3 173.077
rl1730 n43__en_b n44__en_b 203.848
rl1731 n43__en_b n45__en_b 126.923
rl1732 i33__i0__net1 n2__i33__i0__net1 72.3097
rl1733 n2__i33__i0__net1 n3__i33__i0__net1 72.3097
rl1734 n518__clk1pt6g n519__clk1pt6g 71.1559
rl1735 n134__net23 n135__net23 69.2328
rl1736 n135__net23 n136__net23 111.54
rl1737 n43__en n44__en 157.694
rl1738 n43__en n45__en 126.923
rl1739 n111__net29 n112__net29 111.54
rl1740 n520__clk1pt6g n521__clk1pt6g 111.54
rl1741 n323__clk100m n324__clk100m 71.1559
rl1742 n216__clk100m_b n217__clk100m_b 69.2328
rl1743 n217__clk100m_b n218__clk100m_b 111.54
rl1744 n524__clk1pt6g n525__clk1pt6g 153.313
rl1745 n525__clk1pt6g n526__clk1pt6g 27.5641
rl1746 n526__clk1pt6g n527__clk1pt6g 97.6734
rl1747 n527__clk1pt6g n528__clk1pt6g 23.7402
rl1748 n528__clk1pt6g n529__clk1pt6g 51.6131
rl1749 n527__clk1pt6g n530__clk1pt6g 51.6011
rl1750 n529__clk1pt6g n525__clk1pt6g 24.6956
rl1751 n64__net22 n65__net22 51.4019
rl1752 n65__net22 n66__net22 25.7494
rl1753 n66__net22 n67__net22 120.719
rl1754 n67__net22 n68__net22 56.2572
rl1755 n68__net22 n65__net22 36.217
rl1756 n219__clk100m_b n220__clk100m_b 113.464
rl1757 n219__clk100m_b n221__clk100m_b 126.923
rl1758 n24__i28__net13 n25__i28__net13 125.643
rl1759 n25__i28__net13 n26__i28__net13 27.5641
rl1760 n26__i28__net13 n27__i28__net13 23.7402
rl1761 n27__i28__net13 n28__i28__net13 51.6011
rl1762 n27__i28__net13 n29__i28__net13 97.6734
rl1763 n29__i28__net13 n30__i28__net13 51.6131
rl1764 n30__i28__net13 n25__i28__net13 24.6956
rl1765 n8__i28__net11 n9__i28__net11 109.826
rl1766 n9__i28__net11 n10__i28__net11 25.7494
rl1767 n10__i28__net11 n11__i28__net11 51.4019
rl1768 n10__i28__net11 n12__i28__net11 88.6921
rl1769 n12__i28__net11 n8__i28__net11 9.1667
rl1770 i40__i44__x n2__i40__i44__x 35.7713
rl1771 n2__i40__i44__x n3__i40__i44__x 37.6944
rl1772 n202__rst n203__rst 38.1757
rl1773 n203__rst n204__rst 49.3144
rl1774 n203__rst n205__rst 80.4834
rl1775 n205__rst n206__rst 111.54
rl1776 n327__clk100m n328__clk100m 126.923
rl1777 n328__clk100m n329__clk100m 69.2328
rl1778 i29__i143__x n2__i29__i143__x 99.7141
rl1779 n2__i29__i143__x n3__i29__i143__x 50.1123
rl1780 n2__i29__i143__x n4__i29__i143__x 65.0987
rl1781 n125__rst_b n126__rst_b 126.923
rl1782 n126__rst_b n127__rst_b 69.2328
rl1783 i33__i0__x n2__i33__i0__x 99.7141
rl1784 n2__i33__i0__x n3__i33__i0__x 50.1123
rl1785 n2__i33__i0__x n4__i33__i0__x 65.0987
rl1786 n535__clk1pt6g n536__clk1pt6g 111.54
rl1787 n116__net29 n117__net29 111.54
rl1788 n138__net23 n139__net23 71.1559
rl1789 n537__clk1pt6g n538__clk1pt6g 69.2328
rl1790 n538__clk1pt6g n539__clk1pt6g 111.54
rl1791 i28__net6 n2__i28__net6 56.9251
rl1792 n2__i28__net6 n3__i28__net6 120.719
rl1793 n3__i28__net6 n4__i28__net6 70.9615
rl1794 n4__i28__net6 n5__i28__net6 69.0385
rl1795 n5__i28__net6 n6__i28__net6 120.719
rl1796 n6__i28__net6 n7__i28__net6 22.5
rl1797 n4__i28__net6 n8__i28__net6 27.9842
rl1798 n7__i28__net6 i28__net6 27.5021
rl1799 n8__i28__net6 i28__net6 33.1687
rl1800 n223__clk100m_b n224__clk100m_b 71.1559
rl1801 n334__clk100m n335__clk100m 69.2328
rl1802 n335__clk100m n336__clk100m 111.54
rl1803 n1__out14 n2__out14 50.1171
rl1804 n2__out14 n3__out14 40.0987
rl1805 n2__out14 n4__out14 53.5603
rl1806 i29__net4 n2__i29__net4 334.618
rl1807 i29__net4 n3__i29__net4 173.077
rl1808 n46__en_b n47__en_b 203.848
rl1809 n46__en_b n48__en_b 126.923
rl1810 n9__i28__net6 n10__i28__net6 155.407
rl1811 n10__i28__net6 n11__i28__net6 38.0971
rl1812 n11__i28__net6 n12__i28__net6 120.719
rl1813 n12__i28__net6 n13__i28__net6 28.079
rl1814 n13__i28__net6 n14__i28__net6 28.079
rl1815 n14__i28__net6 n15__i28__net6 120.719
rl1816 n15__i28__net6 n16__i28__net6 15
rl1817 n13__i28__net6 n17__i28__net6 34.6687
rl1818 n16__i28__net6 n10__i28__net6 20.4048
rl1819 n17__i28__net6 n10__i28__net6 32.0714
rl1820 n544__clk1pt6g n545__clk1pt6g 71.1559
rl1821 n143__net23 n144__net23 69.2328
rl1822 n144__net23 n145__net23 111.54
rl1823 n46__en n47__en 157.694
rl1824 n46__en n48__en 126.923
rl1825 n120__net29 n121__net29 111.54
rl1826 n546__clk1pt6g n547__clk1pt6g 111.54
rl1827 n230__clk100m_b n231__clk100m_b 113.464
rl1828 n230__clk100m_b n232__clk100m_b 126.923
rl1829 i40__i43__x n2__i40__i43__x 35.7713
rl1830 n2__i40__i43__x n3__i40__i43__x 37.6944
rl1831 n340__clk100m n341__clk100m 126.923
rl1832 n341__clk100m n342__clk100m 69.2328
rl1833 i29__i144__x n2__i29__i144__x 99.7141
rl1834 n2__i29__i144__x n3__i29__i144__x 50.1123
rl1835 n2__i29__i144__x n4__i29__i144__x 65.0987
rl1836 net21 n2__net21 42.1154
rl1837 n2__net21 n3__net21 40.1923
rl1838 n3__net21 n4__net21 120.719
rl1839 n4__net21 n5__net21 37.2834
rl1840 n5__net21 n6__net21 53.7308
rl1841 n5__net21 n7__net21 37.2834
rl1842 n7__net21 n8__net21 108.732
rl1843 n5__net21 n9__net21 30.3602
rl1844 n8__net21 net21 9.1667
rl1845 n9__net21 n2__net21 27.9842
rl1846 n557__clk1pt6g n558__clk1pt6g 111.54
rl1847 n126__net29 n127__net29 111.54
rl1848 n147__net23 n148__net23 71.1559
rl1849 n559__clk1pt6g n560__clk1pt6g 69.2328
rl1850 n560__clk1pt6g n561__clk1pt6g 111.54
rl1851 n1__out15 n2__out15 50.1171
rl1852 n2__out15 n3__out15 40.0987
rl1853 n2__out15 n4__out15 53.5603
rl1854 i29__net8 n2__i29__net8 334.618
rl1855 i29__net8 n3__i29__net8 173.077
rl1856 net24 n2__net24 42.1154
rl1857 n2__net24 n3__net24 40.1923
rl1858 n3__net24 n4__net24 120.719
rl1859 n4__net24 n5__net24 37.2834
rl1860 n5__net24 n6__net24 53.7308
rl1861 n5__net24 n7__net24 37.2834
rl1862 n7__net24 n8__net24 108.732
rl1863 n5__net24 n9__net24 30.3602
rl1864 n8__net24 net24 9.1667
rl1865 n9__net24 n2__net24 27.9842
rl1866 n567__clk1pt6g n568__clk1pt6g 71.1559
rl1867 n152__net23 n153__net23 69.2328
rl1868 n153__net23 n154__net23 111.54
rl1869 n128__net29 n129__net29 111.54
rl1870 n569__clk1pt6g n570__clk1pt6g 111.54
rl1871 i40__i42__x n2__i40__i42__x 35.7713
rl1872 n2__i40__i42__x n3__i40__i42__x 37.6944
rl1873 i29__i161__x n2__i29__i161__x 99.7141
rl1874 n2__i29__i161__x n3__i29__i161__x 50.1123
rl1875 n2__i29__i161__x n4__i29__i161__x 65.0987
rl1876 ext_tx n1__ext_tx 108.462
rl1877 n1__ext_tx n2__ext_tx 38.1757
rl1879 ext_tx n4__ext_tx 6.5385
rl1880 n4__ext_tx n5__ext_tx 84.6154
rl1881 n2__ext_tx n6__ext_tx 80.4834
rl1882 n6__ext_tx n7__ext_tx 115.385
rl1883 n7__ext_tx n8__ext_tx 80.4834
rl1885 n8__ext_tx n10__ext_tx 38.1757
rl1886 n579__clk1pt6g n580__clk1pt6g 111.54
rl1887 n134__net29 n135__net29 111.54
rl1888 n156__net23 n157__net23 71.1559
rl1889 n581__clk1pt6g n582__clk1pt6g 69.2328
rl1890 n582__clk1pt6g n583__clk1pt6g 111.54
rl1892 n2__net25 n3__net25 34.3295
rl1893 n3__net25 n4__net25 115.385
rl1894 n4__net25 n5__net25 34.3295
rl1895 n5__net25 n6__net25 84.3295
rl1896 n2__net25 net25 84.3295
rl1897 n5__net25 n8__net25 50.1123
rl1898 net28 n2__net28 50.1171
rl1899 n2__net28 n3__net28 40.0987
rl1900 n2__net28 n4__net28 53.5603
mi32__i9__i0__pm0 n8__net34 n37__en_b n29__net5 n282__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i9__i1__pm0 n134__vdd n37__en n8__net34 n282__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i11__i0__pm0 n7__net35 n40__en_b n17__net4 n281__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i11__i1__pm0 n144__vdd n40__en n7__net35 n281__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i14__i0__pm0 n7__net36 n43__en_b n14__net3 n280__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i14__i1__pm0 n152__vdd n43__en n7__net36 n280__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i15__i0__pm0 n7__net37 n46__en_b n13__net2 n279__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i15__i1__pm0 n256__vdd n46__en n7__net37 n279__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i5__i0__pm0 n8__net30 n25__en_b n17__net9 n286__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i5__i1__pm0 n94__vdd n25__en n8__net30 n286__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i6__i0__pm0 n9__net31 n28__en_b n17__net8 n285__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i6__i1__pm0 n104__vdd n28__en n9__net31 n285__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i7__i0__pm0 n8__net32 n31__en_b n17__net7 n284__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i7__i1__pm0 n114__vdd n31__en n8__net32 n284__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i8__i0__pm0 n9__net33 n34__en_b n17__net6 n283__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i8__i1__pm0 n124__vdd n34__en n9__net33 n283__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i0__i0__pm0 n8__net40 n13__en_b n17__net13 n290__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i0__i1__pm0 n54__vdd n13__en n8__net40 n290__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i2__i0__pm0 n8__net41 n16__en_b n17__net12 n289__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i2__i1__pm0 n64__vdd n16__en n8__net41 n289__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i3__i0__pm0 n8__net42 n19__en_b n17__net11 n288__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i3__i1__pm0 n74__vdd n19__en n8__net42 n288__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i4__i0__pm0 n8__net43 n22__en_b n17__net10 n287__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i4__i1__pm0 n84__vdd n22__en n8__net43 n287__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i10__i0__pm0 n7__net18 n2__en_b n16__net17 n294__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i10__i1__pm0 n12__vdd n2__en n7__net18 n294__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i13__i0__pm0 n8__net19 n4__en_b n28__net16 n293__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i13__i1__pm0 n24__vdd n4__en n8__net19 n293__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i12__i0__pm0 n8__net38 n7__en_b n17__net15 n292__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i12__i1__pm0 n34__vdd n7__en n8__net38 n292__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i1__i0__pm0 n8__net39 n10__en_b n29__net14 n291__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i1__i1__pm0 n44__vdd n10__en n8__net39 n291__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i2__pm0 n7__i33__i58__net2 n3__net14 n247__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i3__pm0 n16__i33__i58__net1 n9__net5 n210__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i1__pm0 n8__i33__xor1 i33__i58__net1 n3__i33__i58__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i0__pm0 n7__net14 net5 n8__i33__xor1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i2__pm0 n3__i33__i56__net2 n4__i33__xor1 n246__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i3__pm0 n9__i33__i56__net1 n3__i33__xor2 n245__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i1__pm0 n4__i33__d0 i33__i56__net1 n7__i33__i56__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i0__pm0 n14__i33__xor1 n9__i33__xor2 n4__i33__d0 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i2__pm0 n5__i33__i57__net2 n4__net16 n249__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i3__pm0 n14__i33__i57__net1 n7__net17 n250__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i1__pm0 n11__i33__xor2 n6__i33__i57__net1 i33__i57__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i0__pm0 n5__net16 net17 n11__i33__xor2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__pm0 i33__i0__net2 i33__i0__net1 n213__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__pm1 n7__i33__i0__x n323__clk100m i33__i0__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__i6__i1__pm0 n10__i33__i0__net1 n202__rst n6__i33__d0 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__i6__i0__pm0 n249__rst n126__rst_b n10__i33__i0__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__pm2 i33__i0__net4 i33__i0__x n211__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__pm3 n9__net2 n223__clk100m_b i33__i0__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__pm0 i33__i16__net2 i33__i16__net1 n215__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__pm1 n7__i33__i16__x n308__clk100m i33__i16__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__i6__i1__pm0 n11__i33__i16__net1 n186__rst n2__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__i6__i0__pm0 n240__rst n116__rst_b n11__i33__i16__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__pm2 i33__i16__net4 i33__i16__x n214__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__pm3 n10__net3 n209__clk100m_b i33__i16__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__pm0 i33__i18__net2 i33__i18__net1 n217__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__pm1 n7__i33__i18__x n292__clk100m i33__i18__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__i6__i1__pm0 n11__i33__i18__net1 n170__rst n2__net3 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__i6__i0__pm0 n231__rst n106__rst_b n11__i33__i18__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__pm2 i33__i18__net4 i33__i18__x n216__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__pm3 n13__net4 n195__clk100m_b i33__i18__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__pm0 i33__i17__net2 i33__i17__net1 n219__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__pm1 n7__i33__i17__x n277__clk100m i33__i17__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__i6__i1__pm0 n11__i33__i17__net1 n154__rst n2__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__i6__i0__pm0 n220__rst n96__rst_b n11__i33__i17__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__pm2 i33__i17__net4 i33__i17__x n218__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__pm3 n25__net5 n179__clk100m_b i33__i17__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__pm0 i33__i22__net2 i33__i22__net1 n221__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__pm1 n7__i33__i22__x n262__clk100m i33__i22__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__i6__i1__pm0 n11__i33__i22__net1 n138__rst n16__net5 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__i6__i0__pm0 n209__rst n86__rst_b n11__i33__i22__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__pm2 i33__i22__net4 i33__i22__x n220__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__pm3 n13__net6 n165__clk100m_b i33__i22__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__pm0 i33__i19__net2 i33__i19__net1 n223__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__pm1 n7__i33__i19__x n223__clk100m i33__i19__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__i6__i1__pm0 n11__i33__i19__net1 n122__rst n2__net6 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__i6__i0__pm0 n193__rst n76__rst_b n11__i33__i19__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__pm2 i33__i19__net4 i33__i19__x n222__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__pm3 n13__net7 n151__clk100m_b i33__i19__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__pm0 i33__i21__net2 i33__i21__net1 n225__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__pm1 n7__i33__i21__x n208__clk100m i33__i21__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__i6__i1__pm0 n11__i33__i21__net1 n106__rst n2__net7 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__i6__i0__pm0 n177__rst n66__rst_b n11__i33__i21__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__pm2 i33__i21__net4 i33__i21__x n224__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__pm3 n13__net8 n137__clk100m_b i33__i21__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__pm0 i33__i20__net2 i33__i20__net1 n227__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__pm1 n7__i33__i20__x n191__clk100m i33__i20__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__i6__i1__pm0 n11__i33__i20__net1 n90__rst n2__net8 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__i6__i0__pm0 n161__rst n56__rst_b n11__i33__i20__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__pm2 i33__i20__net4 i33__i20__x n226__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__pm3 n13__net9 n123__clk100m_b i33__i20__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__pm0 i33__i30__net2 i33__i30__net1 n229__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__pm1 n7__i33__i30__x n176__clk100m i33__i30__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__i6__i1__pm0 n11__i33__i30__net1 n74__rst n2__net9 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__i6__i0__pm0 n145__rst n46__rst_b n11__i33__i30__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__pm2 i33__i30__net4 i33__i30__x n228__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__pm3 n13__net10 n85__clk100m_b i33__i30__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__pm0 i33__i23__net2 i33__i23__net1 n231__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__pm1 n7__i33__i23__x n161__clk100m i33__i23__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__i6__i1__pm0 n11__i33__i23__net1 n58__rst n2__net10 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__i6__i0__pm0 n129__rst n36__rst_b n11__i33__i23__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__pm2 i33__i23__net4 i33__i23__x n230__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__pm3 n13__net11 n71__clk100m_b i33__i23__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__pm0 i33__i25__net2 i33__i25__net1 n233__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__pm1 n7__i33__i25__x n148__clk100m i33__i25__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__i6__i1__pm0 n11__i33__i25__net1 n42__rst n2__net11 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__i6__i0__pm0 n113__rst n26__rst_b n11__i33__i25__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__pm2 i33__i25__net4 i33__i25__x n232__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__pm3 n13__net12 n57__clk100m_b i33__i25__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__pm0 i33__i24__net2 i33__i24__net1 n235__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__pm1 n7__i33__i24__x n28__clk100m i33__i24__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__i6__i1__pm0 n11__i33__i24__net1 n26__rst n2__net12 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__i6__i0__pm0 n97__rst n16__rst_b n11__i33__i24__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__pm2 i33__i24__net4 i33__i24__x n234__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__pm3 n13__net13 n40__clk100m_b i33__i24__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__pm0 i33__i29__net2 i33__i29__net1 n237__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__pm1 n7__i33__i29__x n19__clk100m i33__i29__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__i6__i1__pm0 n11__i33__i29__net1 n16__rst n2__net13 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__i6__i0__pm0 n81__rst n11__rst_b n11__i33__i29__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__pm2 i33__i29__net4 i33__i29__x n236__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__pm3 n25__net14 n25__clk100m_b i33__i29__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__pm0 i33__i26__net2 i33__i26__net1 n239__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__pm1 n7__i33__i26__x n11__clk100m i33__i26__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__i6__i1__pm0 n11__i33__i26__net1 n11__rst n14__net14 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__i6__i0__pm0 n65__rst n8__rst_b n11__i33__i26__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__pm2 i33__i26__net4 i33__i26__x n238__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__pm3 n13__net15 n17__clk100m_b i33__i26__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__pm0 i33__i28__net2 i33__i28__net1 n241__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__pm1 n7__i33__i28__x n6__clk100m i33__i28__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__i6__i1__pm0 n11__i33__i28__net1 n6__rst n2__net15 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__i6__i0__pm0 n49__rst n5__rst_b n11__i33__i28__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__pm2 i33__i28__net4 i33__i28__x n240__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__pm3 n24__net16 n9__clk100m_b i33__i28__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__pm0 i33__i27__net2 i33__i27__net1 n243__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__pm1 n7__i33__i27__x clk100m i33__i27__net2 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__i6__i1__pm0 n11__i33__i27__net1 n1__rst n15__net16 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__i6__i0__pm0 n33__rst n2__rst_b n11__i33__i27__net1 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__pm2 i33__i27__net4 i33__i27__x n242__vdd n212__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__pm3 n12__net17 n4__clk100m_b i33__i27__net4 n212__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i0__pm0 n8__net28 n6__net25 n11__net20 n300__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i1__pm0 n84__vss n1__ext_tx n8__net28 n300__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0_7__rcx n27__net29 n227__clk1pt6g n382__vdd n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0_6__rcx n379__vdd n229__clk1pt6g n27__net29 n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0_5__rcx n26__net29 n237__clk1pt6g n379__vdd n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0_4__rcx n378__vdd n241__clk1pt6g n26__net29 n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0_3__rcx n24__net29 n249__clk1pt6g n378__vdd n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0_2__rcx n377__vdd n253__clk1pt6g n24__net29 n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0_1__rcx n22__net29 n261__clk1pt6g n377__vdd n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0 n376__vdd n215__clk1pt6g n22__net29 n380__vdd g45p1svt L=45e-9 W=1.92e-6 AD=268.8e-15 AS=268.8e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__pm0 i40__i56__net2 n4__out2 n372__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__pm1 n4__i40__i56__x n297__clk1pt6g i40__i56__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__pm2 i40__i56__net4 i40__i56__x n373__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__pm3 n6__out1 n6__net29 i40__i56__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__pm0 i40__i57__net2 n4__out1 n374__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__pm1 n4__i40__i57__x n277__clk1pt6g i40__i57__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__pm2 i40__i57__net4 i40__i57__x n375__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__pm3 n2__out0 n2__net29 i40__i57__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__pm0 i40__i54__net2 n4__out4 n368__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__pm1 n4__i40__i54__x n318__clk1pt6g i40__i54__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__pm2 i40__i54__net4 i40__i54__x n369__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__pm3 n6__out3 n14__net29 i40__i54__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__pm0 i40__i55__net2 n4__out3 n370__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__pm1 n4__i40__i55__x n309__clk1pt6g i40__i55__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__pm2 i40__i55__net4 i40__i55__x n371__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__pm3 n6__out2 n10__net29 i40__i55__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__pm0 i40__i52__net2 n4__out6 n364__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__pm1 n4__i40__i52__x n361__clk1pt6g i40__i52__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__pm2 i40__i52__net4 i40__i52__x n365__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__pm3 n6__out5 n40__net29 i40__i52__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__pm0 i40__i53__net2 n4__out5 n366__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__pm1 n4__i40__i53__x n339__clk1pt6g i40__i53__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__pm2 i40__i53__net4 i40__i53__x n367__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__pm3 n6__out4 n31__net29 i40__i53__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__pm0 i40__i50__net2 n4__out8 n360__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__pm1 n4__i40__i50__x n399__clk1pt6g i40__i50__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__pm2 i40__i50__net4 i40__i50__x n361__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__pm3 n6__out7 n58__net29 i40__i50__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__pm0 i40__i51__net2 n4__out7 n362__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__pm1 n4__i40__i51__x n380__clk1pt6g i40__i51__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__pm2 i40__i51__net4 i40__i51__x n363__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__pm3 n6__out6 n49__net29 i40__i51__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__pm0 i40__i48__net2 n4__out10 n356__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__pm1 n4__i40__i48__x n437__clk1pt6g i40__i48__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__pm2 i40__i48__net4 i40__i48__x n357__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__pm3 n6__out9 n76__net29 i40__i48__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__pm0 i40__i49__net2 n4__out9 n358__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__pm1 n4__i40__i49__x n418__clk1pt6g i40__i49__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__pm2 i40__i49__net4 i40__i49__x n359__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__pm3 n6__out8 n67__net29 i40__i49__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__pm0 i40__i46__net2 n4__out12 n352__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__pm1 n4__i40__i46__x n487__clk1pt6g i40__i46__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__pm2 i40__i46__net4 i40__i46__x n353__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__pm3 n6__out11 n94__net29 i40__i46__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__pm0 i40__i47__net2 n4__out11 n354__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__pm1 n4__i40__i47__x n461__clk1pt6g i40__i47__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__pm2 i40__i47__net4 i40__i47__x n355__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__pm3 n6__out10 n85__net29 i40__i47__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__pm0 i40__i44__net2 n4__out14 n348__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__pm1 n4__i40__i44__x n535__clk1pt6g i40__i44__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__pm2 i40__i44__net4 i40__i44__x n349__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__pm3 n5__out13 n112__net29 i40__i44__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__pm0 i40__i45__net2 n4__out13 n350__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__pm1 n4__i40__i45__x n509__clk1pt6g i40__i45__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__pm2 i40__i45__net4 i40__i45__x n351__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__pm3 n6__out12 n103__net29 i40__i45__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__pm0 i40__i42__net2 n4__net28 n344__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__pm1 n4__i40__i42__x n579__clk1pt6g i40__i42__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__pm2 i40__i42__net4 i40__i42__x n345__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__pm3 n5__out15 n129__net29 i40__i42__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__pm0 i40__i43__net2 n4__out15 n346__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__pm1 n4__i40__i43__x n557__clk1pt6g i40__i43__net2 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__pm2 i40__i43__net4 i40__i43__x n347__vdd n343__vdd g45p1svt L=45e-9 W=360e-9 AD=57.6e-15 AS=57.6e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__pm3 n5__out14 n121__net29 i40__i43__net4 n343__vdd g45p1svt L=45e-9 W=360e-9 AD=50.4e-15 AS=50.4e-15 PD=1.02e-6 PS=1.02e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i55__pm0_1__rcx n586__vdd n7__i28__net4 n52__i28__net10 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i55__pm0 n52__i28__net10 n6__i28__net4 n581__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_15__rcx n113__clk100m_b n102__clk100m n453__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_14__rcx n462__vdd n106__clk100m n113__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_13__rcx n111__clk100m_b n114__clk100m n462__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_12__rcx n469__vdd n118__clk100m n111__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_11__rcx n109__clk100m_b n126__clk100m n469__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_10__rcx n477__vdd n130__clk100m n109__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_9__rcx n98__clk100m_b n138__clk100m n477__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_8__rcx n484__vdd n142__clk100m n98__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_7__rcx n121__clk100m_b n56__clk100m n418__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_6__rcx n426__vdd n58__clk100m n121__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_5__rcx n119__clk100m_b n66__clk100m n426__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_4__rcx n434__vdd n70__clk100m n119__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_3__rcx n117__clk100m_b n78__clk100m n434__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_2__rcx n443__vdd n82__clk100m n117__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0_1__rcx n115__clk100m_b n90__clk100m n443__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__pm0 n453__vdd n94__clk100m n115__clk100m_b n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i54__pm0_1__rcx n10__i28__net4 n6__i28__net2 n592__vdd n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i54__pm0 n597__vdd n7__i28__net2 n10__i28__net4 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i63__pm0_1__rcx n14__i28__net5 n14__i28__net6 n601__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i63__pm0 n605__vdd n15__i28__net6 n14__i28__net5 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i67__pm0_1__rcx n16__i28__net11 n17__i28__net13 n571__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i67__pm0 n579__vdd n16__i28__net13 n16__i28__net11 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i62__pm0_1__rcx n14__i28__net19 n13__i28__net13 n564__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i62__pm0 n572__vdd n3__i28__net13 n14__i28__net19 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i66__pm0_1__rcx n16__i28__net26 n17__i28__net12 n533__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i66__pm0 n541__vdd n16__i28__net12 n16__i28__net26 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i61__pm0_1__rcx n14__i28__net17 n13__i28__net12 n526__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i61__pm0 n534__vdd n3__i28__net12 n14__i28__net17 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i65__pm0_1__rcx n16__i28__net23 n17__i28__net3 n495__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i65__pm0 n503__vdd n16__i28__net3 n16__i28__net23 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i60__pm0_1__rcx n14__i28__net15 n13__i28__net3 n488__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i60__pm0 n496__vdd n3__i28__net3 n14__i28__net15 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i64__pm0_1__rcx n16__i28__net20 n17__i28__net9 n450__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i64__pm0 n460__vdd n16__i28__net9 n16__i28__net20 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i59__pm0_1__rcx n15__i28__net1 n13__i28__net9 n441__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i59__pm0 n451__vdd n3__i28__net9 n15__i28__net1 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm0_1__rcx n11__i28__i53__net2 n12__i28__net7 n660__vdd n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm0 n662__vdd n11__i28__net7 n11__i28__i53__net2 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm1_1__rcx n9__i28__i53__x n478__clk1pt6g n7__i28__i53__net2 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm1 n3__i28__i53__net2 n476__clk1pt6g n9__i28__i53__x n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm2_1__rcx n13__i28__i53__net4 n6__i28__i53__x n664__vdd n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm2 n666__vdd n5__i28__i53__x n13__i28__i53__net4 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm3_1__rcx n17__i28__net8 n49__net22 n8__i28__i53__net4 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__pm3 n3__i28__i53__net4 n47__net22 n17__i28__net8 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm0_1__rcx n3__i28__i51__net2 n6__i28__net5 n578__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm0 n584__vdd i28__net5 n3__i28__i51__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm1_1__rcx n11__i28__i51__x n3__i28__net11 n7__i28__i51__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm1 n11__i28__i51__net2 n6__i28__net11 n11__i28__i51__x n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm2_1__rcx n3__i28__i51__net4 n6__i28__i51__x n590__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm2 n596__vdd i28__i51__x n3__i28__i51__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm3_1__rcx n20__i28__net6 n26__i28__net13 n8__i28__i51__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__pm3 n13__i28__i51__net4 n29__i28__net13 n20__i28__net6 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm0_1__rcx n3__i28__i72__net2 n6__i28__net19 n540__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm0 n546__vdd i28__net19 n3__i28__i72__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm1_1__rcx n11__i28__i72__x n3__i28__net26 n7__i28__i72__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm1 n11__i28__i72__net2 n6__i28__net26 n11__i28__i72__x n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm2_1__rcx n3__i28__i72__net4 n6__i28__i72__x n552__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm2 n558__vdd i28__i72__x n3__i28__i72__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm3_1__rcx n33__i28__net13 n26__i28__net12 n8__i28__i72__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__pm3 n13__i28__i72__net4 n29__i28__net12 n33__i28__net13 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm0_1__rcx n3__i28__i71__net2 n6__i28__net17 n502__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm0 n508__vdd i28__net17 n3__i28__i71__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm1_1__rcx n11__i28__i71__x n3__i28__net23 n7__i28__i71__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm1 n11__i28__i71__net2 n6__i28__net23 n11__i28__i71__x n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm2_1__rcx n3__i28__i71__net4 n6__i28__i71__x n514__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm2 n520__vdd i28__i71__x n3__i28__i71__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm3_1__rcx n33__i28__net12 n27__i28__net3 n8__i28__i71__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__pm3 n14__i28__i71__net4 n24__i28__net3 n33__i28__net12 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm0_1__rcx n3__i28__i70__net2 n6__i28__net15 n459__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm0 n467__vdd i28__net15 n3__i28__i70__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm1_1__rcx n11__i28__i70__x n3__i28__net20 n7__i28__i70__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm1 n11__i28__i70__net2 n6__i28__net20 n11__i28__i70__x n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm2_1__rcx n3__i28__i70__net4 n6__i28__i70__x n475__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm2 n482__vdd i28__i70__x n3__i28__i70__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm3_1__rcx n33__i28__net3 n26__i28__net9 n8__i28__i70__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__pm3 n14__i28__i70__net4 n29__i28__net9 n33__i28__net3 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm0_1__rcx n11__i28__i52__net2 n6__i28__net6 n652__vdd n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm0 n654__vdd n5__i28__net6 n11__i28__i52__net2 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm1_1__rcx n9__i28__i52__x n528__clk1pt6g n7__i28__i52__net2 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm1 n3__i28__i52__net2 n526__clk1pt6g n9__i28__i52__x n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm2_1__rcx n13__i28__i52__net4 n6__i28__i52__x n656__vdd n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm2 n658__vdd n5__i28__i52__x n13__i28__i52__net4 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm3_1__rcx n29__i28__net7 n61__net22 n8__i28__i52__net4 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__pm3 n3__i28__i52__net4 n59__net22 n29__i28__net7 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm0_1__rcx n3__i28__i69__net2 n6__i28__net1 n409__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm0 n416__vdd i28__net1 n3__i28__i69__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm1_1__rcx n11__i28__i69__x n272__clk1pt6g n7__i28__i69__net2 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm1 n12__i28__i69__net2 n275__clk1pt6g n11__i28__i69__x n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm2_1__rcx n3__i28__i69__net4 n6__i28__i69__x n424__vdd n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm2 n432__vdd i28__i69__x n3__i28__i69__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm3_1__rcx n33__i28__net9 n8__net22 n8__i28__i69__net4 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__pm3 n14__i28__i69__net4 n11__net22 n33__i28__net9 n342__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i9__pm0_1__rcx n670__vdd n6__i28__net8 n10__i28__i50__net1 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i9__pm0 n10__i28__i50__net1 n11__i28__net8 n668__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i8__pm0_1__rcx n673__vdd n6__i28__net7 i28__i50__net2 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i8__pm0 i28__i50__net2 i28__net7 n672__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i11__pm0_1__rcx n9__i28__i50__net2 n6__i28__i50__net1 n15__i28__net2 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i11__pm0 n15__i28__net2 n4__i28__i50__net1 n8__i28__i50__net2 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i10__pm0_1__rcx n23__i28__net7 n9__i28__net8 n11__i28__net2 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i10__pm0 n11__i28__net2 n15__i28__net8 n15__i28__net7 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_15__rcx n536__vdd n94__i28__net14 n248__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_14__rcx n237__clk100m n102__i28__net14 n536__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_13__rcx n543__vdd n106__i28__net14 n237__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0_7__rcx n119__i28__net14 n12__i28__net10 n548__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0_6__rcx n554__vdd n14__i28__net10 n119__i28__net14 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0_5__rcx n117__i28__net14 n22__i28__net10 n554__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0_4__rcx n560__vdd n26__i28__net10 n117__i28__net14 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0_3__rcx n115__i28__net14 n34__i28__net10 n560__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0_2__rcx n566__vdd n38__i28__net10 n115__i28__net14 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0_1__rcx n108__i28__net14 n46__i28__net10 n566__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__pm0 n574__vdd n50__i28__net10 n108__i28__net14 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_12__rcx n248__clk100m n90__i28__net14 n528__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_11__rcx n254__clk100m n54__i28__net14 n510__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_10__rcx n516__vdd n58__i28__net14 n254__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_9__rcx n252__clk100m n66__i28__net14 n516__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_8__rcx n522__vdd n70__i28__net14 n252__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_7__rcx n250__clk100m n78__i28__net14 n522__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_6__rcx n528__vdd n82__i28__net14 n250__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_5__rcx n260__clk100m n20__i28__net14 n490__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_4__rcx n498__vdd n22__i28__net14 n260__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_3__rcx n258__clk100m n30__i28__net14 n498__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_2__rcx n505__vdd n34__i28__net14 n258__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0_1__rcx n256__clk100m n42__i28__net14 n505__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__pm0 n510__vdd n46__i28__net14 n256__clk100m n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__pm0 i29__i144__net2 i29__net4 n630__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__pm1 n7__i29__i144__x n544__clk1pt6g i29__i144__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i160__i0__pm0 n5__i29__net8 n232__clk100m_b net37 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i160__i1__pm0 n4__i29__net7 n341__clk100m n5__i29__net8 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__pm2 i29__i144__net4 i29__i144__x n632__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__pm3 n10__i29__net7 n147__net23 i29__i144__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__pm0 i29__i143__net2 i29__net3 n625__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__pm1 n7__i29__i143__x n518__clk1pt6g i29__i143__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i159__i0__pm0 n5__i29__net4 n221__clk100m_b net36 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i159__i1__pm0 n4__i29__net13 n328__clk100m n5__i29__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__pm2 i29__i143__net4 i29__i143__x n627__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__pm3 n10__i29__net13 n138__net23 i29__i143__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__pm0 i29__i142__net2 i29__net2 n620__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__pm1 n7__i29__i142__x n494__clk1pt6g i29__i142__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i158__i0__pm0 n5__i29__net3 n207__clk100m_b net35 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i158__i1__pm0 n4__i29__net18 n313__clk100m n5__i29__net3 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__pm2 i29__i142__net4 i29__i142__x n622__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__pm3 n10__i29__net18 n129__net23 i29__i142__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__pm0 i29__i141__net2 i29__net1 n615__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__pm1 n7__i29__i141__x n468__clk1pt6g i29__i141__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i157__i0__pm0 n5__i29__net2 n193__clk100m_b net34 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i157__i1__pm0 n4__i29__net34 n297__clk100m n5__i29__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__pm2 i29__i141__net4 i29__i141__x n617__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__pm3 n10__i29__net34 n120__net23 i29__i141__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__pm0 i29__i140__net2 i29__net5 n610__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__pm1 n7__i29__i140__x n444__clk1pt6g i29__i140__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i156__i0__pm0 n5__i29__net1 n177__clk100m_b net33 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i156__i1__pm0 n4__i29__net6 n282__clk100m n5__i29__net1 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__pm2 i29__i140__net4 i29__i140__x n612__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__pm3 n11__i29__net6 n111__net23 i29__i140__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__pm0 i29__i139__net2 i29__net11 n603__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__pm1 n7__i29__i139__x n425__clk1pt6g i29__i139__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i155__i0__pm0 n5__i29__net5 n163__clk100m_b net32 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i155__i1__pm0 n4__i29__net12 n267__clk100m n5__i29__net5 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__pm2 i29__i139__net4 i29__i139__x n607__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__pm3 n11__i29__net12 n102__net23 i29__i139__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__pm0 i29__i138__net2 i29__net31 n588__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__pm1 n7__i29__i138__x n406__clk1pt6g i29__i138__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i154__i0__pm0 n5__i29__net11 n149__clk100m_b net31 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i154__i1__pm0 n4__i29__net25 n228__clk100m n5__i29__net11 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__pm2 i29__i138__net4 i29__i138__x n594__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__pm3 n11__i29__net25 n93__net23 i29__i138__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__pm0 i29__i137__net2 i29__net15 n568__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__pm1 n7__i29__i137__x n387__clk1pt6g i29__i137__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i153__i0__pm0 n5__i29__net31 n135__clk100m_b net30 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i153__i1__pm0 n4__i29__net23 n213__clk100m n5__i29__net31 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__pm2 i29__i137__net4 i29__i137__x n576__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__pm3 n11__i29__net23 n84__net23 i29__i137__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__pm0 i29__i136__net2 i29__net22 n550__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__pm1 n7__i29__i136__x n368__clk1pt6g i29__i136__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i152__i0__pm0 n5__i29__net15 n97__clk100m_b net43 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i152__i1__pm0 n4__i29__net14 n196__clk100m n5__i29__net15 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__pm2 i29__i136__net4 i29__i136__x n556__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__pm3 n11__i29__net14 n75__net23 i29__i136__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__pm0 i29__i135__net2 i29__net30 n530__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__pm1 n7__i29__i135__x n349__clk1pt6g i29__i135__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i151__i0__pm0 n5__i29__net22 n83__clk100m_b net42 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i151__i1__pm0 n4__i29__net21 n181__clk100m n5__i29__net22 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__pm2 i29__i135__net4 i29__i135__x n538__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__pm3 n11__i29__net21 n66__net23 i29__i135__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__pm0 i29__i134__net2 i29__net17 n512__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__pm1 n7__i29__i134__x n325__clk1pt6g i29__i134__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i150__i0__pm0 n5__i29__net30 n69__clk100m_b net41 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i150__i1__pm0 n4__i29__net29 n166__clk100m n5__i29__net30 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__pm2 i29__i134__net4 i29__i134__x n518__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__pm3 n11__i29__net29 n57__net23 i29__i134__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__pm0 i29__i133__net2 i29__net10 n492__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__pm1 n7__i29__i133__x n314__clk1pt6g i29__i133__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i149__i0__pm0 n5__i29__net17 n52__clk100m_b net40 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i149__i1__pm0 n4__i29__net16 n151__clk100m n5__i29__net17 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__pm2 i29__i133__net4 i29__i133__x n500__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__pm3 n11__i29__net16 n46__net23 i29__i133__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__pm0 i29__i132__net2 i29__net20 n471__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__pm1 n7__i29__i132__x n305__clk1pt6g i29__i132__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i148__i0__pm0 n5__i29__net10 n38__clk100m_b net39 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i148__i1__pm0 n4__i29__net9 n31__clk100m n5__i29__net10 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__pm2 i29__i132__net4 i29__i132__x n479__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__pm3 n11__i29__net9 n14__net23 i29__i132__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__pm0 i29__i131__net2 i29__net27 n445__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__pm1 n7__i29__i131__x n288__clk1pt6g i29__i131__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i147__i0__pm0 n5__i29__net20 n24__clk100m_b net38 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i147__i1__pm0 n4__i29__net19 n22__clk100m n5__i29__net20 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__pm2 i29__i131__net4 i29__i131__x n455__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__pm3 n11__i29__net19 n9__net23 i29__i131__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__pm0 i29__i130__net2 net18 n420__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__pm1 n7__i29__i130__x n266__clk1pt6g i29__i130__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i146__i0__pm0 n5__i29__net27 n16__clk100m_b net19 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i146__i1__pm0 n4__i29__net26 n14__clk100m n5__i29__net27 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__pm2 i29__i130__net4 i29__i130__x n428__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__pm3 n11__i29__net26 n4__net23 i29__i130__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi37__pm0_1__rcx n641__vdd net24 n6__net1 n411__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi37__pm0 n6__net1 n7__net24 n644__vdd n411__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_15__rcx n36__net23 n174__clk1pt6g n438__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_14__rcx n430__vdd n178__clk1pt6g n36__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_13__rcx n34__net23 n186__clk1pt6g n430__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_12__rcx n422__vdd n190__clk1pt6g n34__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_11__rcx n32__net23 n198__clk1pt6g n422__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_10__rcx n414__vdd n202__clk1pt6g n32__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_9__rcx n19__net23 n210__clk1pt6g n414__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_8__rcx n407__vdd n108__clk1pt6g n19__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_7__rcx n43__net23 n128__clk1pt6g n473__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_6__rcx n465__vdd n130__clk1pt6g n43__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_5__rcx n42__net23 n138__clk1pt6g n465__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_4__rcx n457__vdd n142__clk1pt6g n42__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_3__rcx n40__net23 n150__clk1pt6g n457__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_2__rcx n447__vdd n154__clk1pt6g n40__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0_1__rcx n38__net23 n162__clk1pt6g n447__vdd n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0 n438__vdd n166__clk1pt6g n38__net23 n480__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_15__rcx n30__net22 n67__clk1pt6g n394__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_14__rcx n396__vdd n71__clk1pt6g n30__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_13__rcx n28__net22 n79__clk1pt6g n396__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_12__rcx n398__vdd n83__clk1pt6g n28__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_11__rcx n26__net22 n91__clk1pt6g n398__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_10__rcx n400__vdd n95__clk1pt6g n26__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_9__rcx n13__net22 n103__clk1pt6g n400__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_8__rcx n402__vdd n1__clk1pt6g n13__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_7__rcx n37__net22 n21__clk1pt6g n386__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_6__rcx n388__vdd n23__clk1pt6g n37__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_5__rcx n36__net22 n31__clk1pt6g n388__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_4__rcx n390__vdd n35__clk1pt6g n36__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_3__rcx n34__net22 n43__clk1pt6g n390__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_2__rcx n392__vdd n47__clk1pt6g n34__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0_1__rcx n32__net22 n55__clk1pt6g n392__vdd n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0 n394__vdd n59__clk1pt6g n32__net22 n342__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi36__pm0_1__rcx n12__net24 n7__net21 n648__vdd n411__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi36__pm0 n646__vdd net21 n12__net24 n411__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi38__pm0 n11__net25 n4__ext_tx n299__vdd n300__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i0__pm0 n8__net20 net25 net1 n411__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i1__pm0 net1 n10__ext_tx n81__vss n411__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__pm3 n11__net21 n156__net23 i29__i161__net4 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__pm2 i29__i161__net4 i29__i161__x n637__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__pm1 n7__i29__i161__x n567__clk1pt6g i29__i161__net2 n436__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__pm0 i29__i161__net2 i29__net8 n635__vdd n436__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i9__i1__nm0 n7__net34 n39__en_b n129__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i9__i0__nm0 n38__net5 n39__en n7__net34 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i11__i1__nm0 n6__net35 n42__en_b n139__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i11__i0__nm0 n23__net4 n42__en n6__net35 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i14__i1__nm0 n6__net36 n45__en_b n147__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i14__i0__nm0 n17__net3 n45__en n6__net36 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i15__i1__nm0 n6__net37 n48__en_b n251__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i15__i0__nm0 n16__net2 n48__en n6__net37 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i5__i1__nm0 n7__net30 n27__en_b n89__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i5__i0__nm0 n24__net9 n27__en n7__net30 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i6__i1__nm0 n8__net31 n30__en_b n99__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i6__i0__nm0 n24__net8 n30__en n8__net31 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i7__i1__nm0 n7__net32 n33__en_b n109__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i7__i0__nm0 n24__net7 n33__en n7__net32 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i8__i1__nm0 n8__net33 n36__en_b n119__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i8__i0__nm0 n24__net6 n36__en n8__net33 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i0__i1__nm0 n7__net40 n15__en_b n49__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i0__i0__nm0 n24__net13 n15__en n7__net40 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i2__i1__nm0 n7__net41 n18__en_b n59__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i2__i0__nm0 n24__net12 n18__en n7__net41 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i3__i1__nm0 n7__net42 n21__en_b n69__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i3__i0__nm0 n24__net11 n21__en n7__net42 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i4__i1__nm0 n7__net43 n24__en_b n79__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i4__i0__nm0 n24__net10 n24__en n7__net43 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i10__i1__nm0 n6__net18 n3__en_b n7__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i10__i0__nm0 n24__net17 n3__en n6__net18 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i13__i1__nm0 n7__net19 n6__en_b n19__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i13__i0__nm0 n37__net16 n6__en n7__net19 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i12__i1__nm0 n7__net38 n9__en_b n29__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i12__i0__nm0 n24__net15 n9__en n7__net38 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i1__i1__nm0 n7__net39 n12__en_b n39__vdd n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi32__i1__i0__nm0 n36__net14 n12__en n7__net39 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i2__nm0 n5__i33__i58__net2 n4__net14 n231__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i3__nm0 n14__i33__i58__net1 n7__net5 n160__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i1__nm0 n6__i33__xor1 n5__net5 i33__i58__net2 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i58__i0__nm0 n8__net14 n4__i33__i58__net1 n6__i33__xor1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i2__nm0 i33__i56__net2 i33__xor1 n230__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i3__nm0 n7__i33__i56__net1 n2__i33__xor2 n229__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i1__nm0 i33__d0 n7__i33__xor2 n5__i33__i56__net2 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i56__i0__nm0 n16__i33__xor1 n5__i33__i56__net1 i33__d0 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i2__nm0 n7__i33__i57__net2 n3__net16 n264__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i3__nm0 n16__i33__i57__net1 n8__net17 n196__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i1__nm0 n13__i33__xor2 n6__net17 n3__i33__i57__net2 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i57__i0__nm0 n7__net16 i33__i57__net1 n13__i33__xor2 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__nm2 n11__net2 n335__clk100m i33__i0__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__nm3 i33__i0__net5 n4__i33__i0__x n228__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__nm0 n6__i33__i0__x n217__clk100m_b i33__i0__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__nm1 i33__i0__net3 n3__i33__i0__net1 n227__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__i6__i1__nm0 n11__i33__d0 n125__rst_b n8__i33__i0__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i0__i6__i0__nm0 n8__i33__i0__net1 n205__rst n244__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__nm2 n12__net3 n320__clk100m i33__i16__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__nm3 i33__i16__net5 n4__i33__i16__x n226__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__nm0 n6__i33__i16__x n203__clk100m_b i33__i16__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__nm1 i33__i16__net3 n3__i33__i16__net1 n225__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__i6__i1__nm0 n8__net2 n115__rst_b n9__i33__i16__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i16__i6__i0__nm0 n9__i33__i16__net1 n189__rst n235__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__nm2 n15__net4 n305__clk100m i33__i18__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__nm3 i33__i18__net5 n4__i33__i18__x n224__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__nm0 n6__i33__i18__x n189__clk100m_b i33__i18__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__nm1 i33__i18__net3 n3__i33__i18__net1 n223__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__i6__i1__nm0 n8__net3 n105__rst_b n9__i33__i18__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i18__i6__i0__nm0 n9__i33__i18__net1 n173__rst n224__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__nm2 n27__net5 n289__clk100m i33__i17__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__nm3 i33__i17__net5 n4__i33__i17__x n222__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__nm0 n6__i33__i17__x n173__clk100m_b i33__i17__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__nm1 i33__i17__net3 n3__i33__i17__net1 n221__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__i6__i1__nm0 n8__net4 n95__rst_b n9__i33__i17__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i17__i6__i0__nm0 n9__i33__i17__net1 n157__rst n213__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__nm2 n15__net6 n274__clk100m i33__i22__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__nm3 i33__i22__net5 n4__i33__i22__x n220__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__nm0 n6__i33__i22__x n159__clk100m_b i33__i22__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__nm1 i33__i22__net3 n3__i33__i22__net1 n219__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__i6__i1__nm0 n22__net5 n85__rst_b n9__i33__i22__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i22__i6__i0__nm0 n9__i33__i22__net1 n141__rst n197__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__nm2 n15__net7 n235__clk100m i33__i19__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__nm3 i33__i19__net5 n4__i33__i19__x n218__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__nm0 n6__i33__i19__x n145__clk100m_b i33__i19__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__nm1 i33__i19__net3 n3__i33__i19__net1 n217__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__i6__i1__nm0 n8__net6 n75__rst_b n9__i33__i19__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i19__i6__i0__nm0 n9__i33__i19__net1 n125__rst n181__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__nm2 n15__net8 n220__clk100m i33__i21__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__nm3 i33__i21__net5 n4__i33__i21__x n216__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__nm0 n6__i33__i21__x n131__clk100m_b i33__i21__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__nm1 i33__i21__net3 n3__i33__i21__net1 n215__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__i6__i1__nm0 n8__net7 n65__rst_b n9__i33__i21__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i21__i6__i0__nm0 n9__i33__i21__net1 n109__rst n165__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__nm2 n15__net9 n205__clk100m i33__i20__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__nm3 i33__i20__net5 n4__i33__i20__x n214__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__nm0 n6__i33__i20__x n93__clk100m_b i33__i20__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__nm1 i33__i20__net3 n3__i33__i20__net1 n213__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__i6__i1__nm0 n8__net8 n55__rst_b n9__i33__i20__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i20__i6__i0__nm0 n9__i33__i20__net1 n93__rst n149__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__nm2 n15__net10 n188__clk100m i33__i30__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__nm3 i33__i30__net5 n4__i33__i30__x n212__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__nm0 n6__i33__i30__x n79__clk100m_b i33__i30__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__nm1 i33__i30__net3 n3__i33__i30__net1 n211__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__i6__i1__nm0 n8__net9 n45__rst_b n9__i33__i30__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i30__i6__i0__nm0 n9__i33__i30__net1 n77__rst n133__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__nm2 n15__net11 n173__clk100m i33__i23__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__nm3 i33__i23__net5 n4__i33__i23__x n210__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__nm0 n6__i33__i23__x n65__clk100m_b i33__i23__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__nm1 i33__i23__net3 n3__i33__i23__net1 n209__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__i6__i1__nm0 n8__net10 n35__rst_b n9__i33__i23__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i23__i6__i0__nm0 n9__i33__i23__net1 n61__rst n117__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__nm2 n15__net12 n158__clk100m i33__i25__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__nm3 i33__i25__net5 n4__i33__i25__x n208__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__nm0 n6__i33__i25__x n48__clk100m_b i33__i25__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__nm1 i33__i25__net3 n3__i33__i25__net1 n207__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__i6__i1__nm0 n8__net11 n25__rst_b n9__i33__i25__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i25__i6__i0__nm0 n9__i33__i25__net1 n45__rst n101__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__nm2 n15__net13 n145__clk100m i33__i24__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__nm3 i33__i24__net5 n4__i33__i24__x n206__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__nm0 n6__i33__i24__x n34__clk100m_b i33__i24__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__nm1 i33__i24__net3 n3__i33__i24__net1 n205__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__i6__i1__nm0 n8__net12 n15__rst_b n9__i33__i24__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i24__i6__i0__nm0 n9__i33__i24__net1 n29__rst n85__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__nm2 n27__net14 n25__clk100m i33__i29__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__nm3 i33__i29__net5 n4__i33__i29__x n204__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__nm0 n6__i33__i29__x n20__clk100m_b i33__i29__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__nm1 i33__i29__net3 n3__i33__i29__net1 n203__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__i6__i1__nm0 n8__net13 n10__rst_b n9__i33__i29__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i29__i6__i0__nm0 n9__i33__i29__net1 n19__rst n69__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__nm2 n15__net15 n17__clk100m i33__i26__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__nm3 i33__i26__net5 n4__i33__i26__x n202__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__nm0 n6__i33__i26__x n12__clk100m_b i33__i26__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__nm1 i33__i26__net3 n3__i33__i26__net1 n201__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__i6__i1__nm0 n22__net14 n7__rst_b n9__i33__i26__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i26__i6__i0__nm0 n9__i33__i26__net1 n14__rst n53__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__nm2 n26__net16 n9__clk100m i33__i28__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__nm3 i33__i28__net5 n4__i33__i28__x n200__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__nm0 n6__i33__i28__x n7__clk100m_b i33__i28__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__nm1 i33__i28__net3 n3__i33__i28__net1 n199__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__i6__i1__nm0 n8__net15 n4__rst_b n9__i33__i28__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i28__i6__i0__nm0 n9__i33__i28__net1 n9__rst n37__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__nm2 n14__net17 n4__clk100m i33__i27__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__nm3 i33__i27__net5 n4__i33__i27__x n198__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__nm0 n6__i33__i27__x n2__clk100m_b i33__i27__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__nm1 i33__i27__net3 n3__i33__i27__net1 n197__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__i6__i1__nm0 n21__net16 n1__rst_b n9__i33__i27__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi33__i27__i6__i0__nm0 n9__i33__i27__net1 n4__rst n21__rst n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i1__nm0 n5__net28 n4__net25 n482__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i0__nm0 n4__net20 n6__ext_tx n5__net28 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0_7__rcx n20__net29 n224__clk1pt6g n327__vss n11__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0_6__rcx n423__vss n231__clk1pt6g n20__net29 n11__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0_5__rcx n25__net29 n235__clk1pt6g n423__vss n11__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0_4__rcx n422__vss n243__clk1pt6g n25__net29 n11__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0_3__rcx n23__net29 n247__clk1pt6g n422__vss n11__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0_2__rcx n421__vss n255__clk1pt6g n23__net29 n11__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0_1__rcx n21__net29 n259__clk1pt6g n421__vss n11__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0 n420__vss n217__clk1pt6g n21__net29 n11__vss g45n1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__nm1 i40__i56__net3 n3__out2 n416__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__nm0 n6__i40__i56__x n7__net29 i40__i56__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__nm3 i40__i56__net5 n3__i40__i56__x n417__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i56__nm2 n8__out1 n291__clk1pt6g i40__i56__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__nm1 i40__i57__net3 n3__out1 n418__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__nm0 n6__i40__i57__x n3__net29 i40__i57__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__nm3 i40__i57__net5 n3__i40__i57__x n419__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i57__nm2 n3__out0 n269__clk1pt6g i40__i57__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__nm1 i40__i54__net3 n3__out4 n412__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__nm0 n6__i40__i54__x n28__net29 i40__i54__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__nm3 i40__i54__net5 n3__i40__i54__x n413__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i54__nm2 n8__out3 n317__clk1pt6g i40__i54__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__nm1 i40__i55__net3 n3__out3 n414__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__nm0 n6__i40__i55__x n11__net29 i40__i55__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__nm3 i40__i55__net5 n3__i40__i55__x n415__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i55__nm2 n8__out2 n308__clk1pt6g i40__i55__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__nm1 i40__i52__net3 n3__out6 n408__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__nm0 n6__i40__i52__x n46__net29 i40__i52__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__nm3 i40__i52__net5 n3__i40__i52__x n409__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i52__nm2 n8__out5 n352__clk1pt6g i40__i52__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__nm1 i40__i53__net3 n3__out5 n410__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__nm0 n6__i40__i53__x n35__net29 i40__i53__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__nm3 i40__i53__net5 n3__i40__i53__x n411__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i53__nm2 n8__out4 n329__clk1pt6g i40__i53__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__nm1 i40__i50__net3 n3__out8 n404__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__nm0 n6__i40__i50__x n64__net29 i40__i50__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__nm3 i40__i50__net5 n3__i40__i50__x n405__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i50__nm2 n8__out7 n390__clk1pt6g i40__i50__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__nm1 i40__i51__net3 n3__out7 n406__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__nm0 n6__i40__i51__x n55__net29 i40__i51__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__nm3 i40__i51__net5 n3__i40__i51__x n407__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i51__nm2 n8__out6 n371__clk1pt6g i40__i51__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__nm1 i40__i48__net3 n3__out10 n400__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__nm0 n6__i40__i48__x n82__net29 i40__i48__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__nm3 i40__i48__net5 n3__i40__i48__x n401__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i48__nm2 n8__out9 n428__clk1pt6g i40__i48__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__nm1 i40__i49__net3 n3__out9 n402__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__nm0 n6__i40__i49__x n73__net29 i40__i49__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__nm3 i40__i49__net5 n3__i40__i49__x n403__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i49__nm2 n8__out8 n409__clk1pt6g i40__i49__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__nm1 i40__i46__net3 n3__out12 n396__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__nm0 n6__i40__i46__x n100__net29 i40__i46__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__nm3 i40__i46__net5 n3__i40__i46__x n397__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i46__nm2 n8__out11 n471__clk1pt6g i40__i46__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__nm1 i40__i47__net3 n3__out11 n398__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__nm0 n6__i40__i47__x n91__net29 i40__i47__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__nm3 i40__i47__net5 n3__i40__i47__x n399__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i47__nm2 n8__out10 n447__clk1pt6g i40__i47__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__nm1 i40__i44__net3 n3__out14 n392__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__nm0 n6__i40__i44__x n116__net29 i40__i44__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__nm3 i40__i44__net5 n3__i40__i44__x n393__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i44__nm2 n8__out13 n521__clk1pt6g i40__i44__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__nm1 i40__i45__net3 n3__out13 n394__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__nm0 n6__i40__i45__x n107__net29 i40__i45__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__nm3 i40__i45__net5 n3__i40__i45__x n395__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i45__nm2 n8__out12 n497__clk1pt6g i40__i45__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__nm1 i40__i42__net3 n3__net28 n388__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__nm0 n6__i40__i42__x n134__net29 i40__i42__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__nm3 i40__i42__net5 n3__i40__i42__x n389__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i42__nm2 n8__out15 n570__clk1pt6g i40__i42__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__nm1 i40__i43__net3 n3__out15 n390__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__nm0 n6__i40__i43__x n126__net29 i40__i43__net3 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__nm3 i40__i43__net5 n3__i40__i43__x n391__vss n11__vss g45n1svt L=45e-9 W=180e-9 AD=28.8e-15 AS=28.8e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi40__i43__nm2 n8__out14 n547__clk1pt6g i40__i43__net5 n11__vss g45n1svt L=45e-9 W=180e-9 AD=25.2e-15 AS=25.2e-15 PD=660e-9 PS=660e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i55__nm0_1__rcx n54__i28__net10 n4__i28__net4 n54__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i55__nm0 n53__vss n3__i28__net4 n54__i28__net10 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_15__rcx n112__clk100m_b n100__clk100m n73__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_14__rcx n72__vss n108__clk100m n112__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_13__rcx n110__clk100m_b n112__clk100m n72__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_12__rcx n71__vss n120__clk100m n110__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_11__rcx n108__clk100m_b n124__clk100m n71__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_10__rcx n70__vss n132__clk100m n108__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_9__rcx n107__clk100m_b n136__clk100m n70__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_8__rcx n69__vss n39__clk100m n107__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_7__rcx n120__clk100m_b n54__clk100m n77__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_6__rcx n76__vss n60__clk100m n120__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_5__rcx n118__clk100m_b n64__clk100m n76__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_4__rcx n75__vss n72__clk100m n118__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_3__rcx n116__clk100m_b n76__clk100m n75__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_2__rcx n74__vss n84__clk100m n116__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0_1__rcx n114__clk100m_b n88__clk100m n74__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i75__nm0 n73__vss n96__clk100m n114__clk100m_b n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i54__nm0_1__rcx n12__i28__net4 n4__i28__net2 n52__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i54__nm0 n25__vss n3__i28__net2 n12__i28__net4 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i63__nm0_1__rcx n13__i28__net5 n12__i28__net6 n425__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i63__nm0 n485__vss n11__i28__net6 n13__i28__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i67__nm0_1__rcx n15__i28__net11 n9__i28__net13 n431__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i67__nm0 n486__vss n10__i28__net13 n15__i28__net11 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i62__nm0_1__rcx n13__i28__net19 n6__i28__net13 n433__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i62__nm0 n487__vss n5__i28__net13 n13__i28__net19 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i66__nm0_1__rcx n15__i28__net26 n9__i28__net12 n439__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i66__nm0 n488__vss n10__i28__net12 n15__i28__net26 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i61__nm0_1__rcx n13__i28__net17 n6__i28__net12 n441__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i61__nm0 n489__vss n5__i28__net12 n13__i28__net17 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i65__nm0_1__rcx n15__i28__net23 n9__i28__net3 n447__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i65__nm0 n490__vss n10__i28__net3 n15__i28__net23 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i60__nm0_1__rcx n13__i28__net15 n6__i28__net3 n449__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i60__nm0 n491__vss n5__i28__net3 n13__i28__net15 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i64__nm0_1__rcx n15__i28__net20 n9__i28__net9 n455__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i64__nm0 n492__vss n10__i28__net9 n15__i28__net20 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i59__nm0_1__rcx n14__i28__net1 n6__i28__net9 n457__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i59__nm0 n493__vss n5__i28__net9 n14__i28__net1 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm1_1__rcx n5__i28__i53__net3 n8__i28__net7 n475__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm1 n476__vss n9__i28__net7 n5__i28__i53__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm0_1__rcx n11__i28__i53__x n54__net22 n3__i28__i53__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm0 i28__i53__net3 n55__net22 n11__i28__i53__x n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm3_1__rcx n5__i28__i53__net5 n2__i28__i53__x n477__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm3 n478__vss n3__i28__i53__x n5__i28__i53__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm2_1__rcx n19__i28__net8 n452__clk1pt6g n3__i28__i53__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i53__nm2 i28__i53__net5 n453__clk1pt6g n19__i28__net8 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm1_1__rcx i28__i51__net3 n4__i28__net5 n429__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm1 n428__vss n3__i28__net5 i28__i51__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm0_1__rcx n10__i28__i51__x n20__i28__net13 n3__i28__i51__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm0 n5__i28__i51__net3 n19__i28__net13 n10__i28__i51__x n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm3_1__rcx i28__i51__net5 n4__i28__i51__x n427__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm3 n426__vss n3__i28__i51__x i28__i51__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm2_1__rcx n19__i28__net6 n9__i28__net11 n3__i28__i51__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i51__nm2 n5__i28__i51__net5 n8__i28__net11 n19__i28__net6 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm1_1__rcx i28__i72__net3 n4__i28__net19 n437__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm1 n436__vss n3__i28__net19 i28__i72__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm0_1__rcx n10__i28__i72__x n20__i28__net12 n3__i28__i72__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm0 n5__i28__i72__net3 n19__i28__net12 n10__i28__i72__x n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm3_1__rcx i28__i72__net5 n4__i28__i72__x n435__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm3 n434__vss n3__i28__i72__x i28__i72__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm2_1__rcx n32__i28__net13 n9__i28__net26 n3__i28__i72__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i72__nm2 n5__i28__i72__net5 n8__i28__net26 n32__i28__net13 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm1_1__rcx i28__i71__net3 n4__i28__net17 n445__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm1 n444__vss n3__i28__net17 i28__i71__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm0_1__rcx n10__i28__i71__x n20__i28__net3 n3__i28__i71__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm0 n5__i28__i71__net3 n19__i28__net3 n10__i28__i71__x n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm3_1__rcx i28__i71__net5 n4__i28__i71__x n443__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm3 n442__vss n3__i28__i71__x i28__i71__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm2_1__rcx n32__i28__net12 n9__i28__net23 n3__i28__i71__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i71__nm2 n6__i28__i71__net5 n8__i28__net23 n32__i28__net12 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm1_1__rcx i28__i70__net3 n4__i28__net15 n453__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm1 n452__vss n3__i28__net15 i28__i70__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm0_1__rcx n10__i28__i70__x n20__i28__net9 n3__i28__i70__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm0 n5__i28__i70__net3 n19__i28__net9 n10__i28__i70__x n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm3_1__rcx i28__i70__net5 n4__i28__i70__x n451__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm3 n450__vss n3__i28__i70__x i28__i70__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm2_1__rcx n32__i28__net3 n9__i28__net20 n3__i28__i70__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i70__nm2 n6__i28__i70__net5 n8__i28__net20 n32__i28__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm1_1__rcx n5__i28__i52__net3 n2__i28__net6 n471__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm1 n472__vss n3__i28__net6 n5__i28__i52__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm0_1__rcx n11__i28__i52__x n66__net22 n3__i28__i52__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm0 i28__i52__net3 n67__net22 n11__i28__i52__x n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm3_1__rcx n5__i28__i52__net5 n2__i28__i52__x n473__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm3 n474__vss n3__i28__i52__x n5__i28__i52__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm2_1__rcx n31__i28__net7 n502__clk1pt6g n3__i28__i52__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i52__nm2 i28__i52__net5 n503__clk1pt6g n31__i28__net7 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm1_1__rcx i28__i69__net3 n4__i28__net1 n461__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm1 n460__vss n3__i28__net1 i28__i69__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm0_1__rcx n10__i28__i69__x n2__net22 n3__i28__i69__net3 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm0 n6__i28__i69__net3 net22 n10__i28__i69__x n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm3_1__rcx i28__i69__net5 n4__i28__i69__x n459__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm3 n458__vss n3__i28__i69__x i28__i69__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm2_1__rcx n32__i28__net9 n293__clk1pt6g n3__i28__i69__net5 n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i69__nm2 n6__i28__i69__net5 n292__clk1pt6g n32__i28__net9 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_15__rcx n251__clk100m n64__i28__net14 n64__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_14__rcx n63__vss n72__i28__net14 n251__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_13__rcx n249__clk100m n76__i28__net14 n63__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_12__rcx n62__vss n84__i28__net14 n249__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_11__rcx n247__clk100m n88__i28__net14 n62__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_10__rcx n61__vss n96__i28__net14 n247__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_9__rcx n246__clk100m n100__i28__net14 n61__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_8__rcx n60__vss n3__i28__net14 n246__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_7__rcx n259__clk100m n18__i28__net14 n68__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_6__rcx n67__vss n24__i28__net14 n259__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_5__rcx n257__clk100m n28__i28__net14 n67__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_4__rcx n66__vss n36__i28__net14 n257__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_3__rcx n255__clk100m n40__i28__net14 n66__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_2__rcx n65__vss n48__i28__net14 n255__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0_1__rcx n253__clk100m n52__i28__net14 n65__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i74__nm0 n64__vss n60__i28__net14 n253__clk100m n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i9__nm0_1__rcx n480__vss n4__i28__net8 n12__i28__i50__net1 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i9__nm0 n12__i28__i50__net1 n13__i28__net8 n479__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i8__nm0_1__rcx n380__vss n4__i28__net7 n6__i28__i50__net2 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i8__nm0 n6__i28__i50__net2 n5__i28__net7 n481__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i11__nm0_1__rcx n5__i28__i50__net2 n10__i28__net8 n17__i28__net2 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i11__nm0 n17__i28__net2 i28__net8 n7__i28__i50__net2 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i10__nm0_1__rcx n20__i28__net7 n3__i28__i50__net1 n13__i28__net2 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i50__i10__nm0 n13__i28__net2 i28__i50__net1 n17__i28__net7 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0_7__rcx n118__i28__net14 n10__i28__net10 n59__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0_6__rcx n58__vss n16__i28__net10 n118__i28__net14 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0_5__rcx n116__i28__net14 n20__i28__net10 n58__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0_4__rcx n57__vss n28__i28__net10 n116__i28__net14 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0_3__rcx n114__i28__net14 n32__i28__net10 n57__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0_2__rcx n56__vss n40__i28__net10 n114__i28__net14 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0_1__rcx n113__i28__net14 n44__i28__net10 n56__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi28__i73__nm0 n55__vss n3__i28__net10 n113__i28__net14 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__nm2 n12__i29__net7 n560__clk1pt6g i29__i144__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__nm3 i29__i144__net5 n4__i29__i144__x n233__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__nm0 n6__i29__i144__x n144__net23 i29__i144__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i144__nm1 i29__i144__net3 n3__i29__net4 n234__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i160__i0__nm0 n8__net37 n340__clk100m n6__i29__net8 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i160__i1__nm0 n6__i29__net8 n230__clk100m_b i29__net7 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__nm2 n12__i29__net13 n538__clk1pt6g i29__i143__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__nm3 i29__i143__net5 n4__i29__i143__x n235__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__nm0 n6__i29__i143__x n135__net23 i29__i143__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i143__nm1 i29__i143__net3 n3__i29__net3 n236__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i159__i0__nm0 n8__net36 n327__clk100m n6__i29__net4 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i159__i1__nm0 n6__i29__net4 n219__clk100m_b i29__net13 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__nm2 n12__i29__net18 n512__clk1pt6g i29__i142__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__nm3 i29__i142__net5 n4__i29__i142__x n237__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__nm0 n6__i29__i142__x n126__net23 i29__i142__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i142__nm1 i29__i142__net3 n3__i29__net2 n238__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i158__i0__nm0 n8__net35 n312__clk100m n6__i29__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i158__i1__nm0 n6__i29__net3 n205__clk100m_b i29__net18 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__nm2 n12__i29__net34 n490__clk1pt6g i29__i141__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__nm3 i29__i141__net5 n4__i29__i141__x n239__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__nm0 n6__i29__i141__x n117__net23 i29__i141__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i141__nm1 i29__i141__net3 n3__i29__net1 n240__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i157__i0__nm0 n10__net34 n296__clk100m n6__i29__net2 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i157__i1__nm0 n6__i29__net2 n191__clk100m_b i29__net34 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__nm2 n13__i29__net6 n464__clk1pt6g i29__i140__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__nm3 i29__i140__net5 n4__i29__i140__x n241__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__nm0 n6__i29__i140__x n108__net23 i29__i140__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i140__nm1 i29__i140__net3 n3__i29__net5 n242__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i156__i0__nm0 n11__net33 n281__clk100m n6__i29__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i156__i1__nm0 n6__i29__net1 n175__clk100m_b i29__net6 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__nm2 n13__i29__net12 n440__clk1pt6g i29__i139__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__nm3 i29__i139__net5 n4__i29__i139__x n243__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__nm0 n6__i29__i139__x n99__net23 i29__i139__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i139__nm1 i29__i139__net3 n3__i29__net11 n244__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i155__i0__nm0 n11__net32 n266__clk100m n6__i29__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i155__i1__nm0 n6__i29__net5 n161__clk100m_b i29__net12 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__nm2 n13__i29__net25 n421__clk1pt6g i29__i138__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__nm3 i29__i138__net5 n4__i29__i138__x n245__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__nm0 n6__i29__i138__x n90__net23 i29__i138__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i138__nm1 i29__i138__net3 n3__i29__net31 n246__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i154__i0__nm0 n11__net31 n227__clk100m n6__i29__net11 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i154__i1__nm0 n6__i29__net11 n147__clk100m_b i29__net25 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__nm2 n13__i29__net23 n402__clk1pt6g i29__i137__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__nm3 i29__i137__net5 n4__i29__i137__x n247__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__nm0 n6__i29__i137__x n81__net23 i29__i137__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i137__nm1 i29__i137__net3 n3__i29__net15 n248__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i153__i0__nm0 n11__net30 n212__clk100m n6__i29__net31 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i153__i1__nm0 n6__i29__net31 n133__clk100m_b i29__net23 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__nm2 n13__i29__net14 n383__clk1pt6g i29__i136__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__nm3 i29__i136__net5 n4__i29__i136__x n249__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__nm0 n6__i29__i136__x n72__net23 i29__i136__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i136__nm1 i29__i136__net3 n3__i29__net22 n250__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i152__i0__nm0 n11__net43 n195__clk100m n6__i29__net15 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i152__i1__nm0 n6__i29__net15 n95__clk100m_b i29__net14 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__nm2 n13__i29__net21 n364__clk1pt6g i29__i135__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__nm3 i29__i135__net5 n4__i29__i135__x n251__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__nm0 n6__i29__i135__x n63__net23 i29__i135__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i135__nm1 i29__i135__net3 n3__i29__net30 n252__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i151__i0__nm0 n11__net42 n180__clk100m n6__i29__net22 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i151__i1__nm0 n6__i29__net22 n81__clk100m_b i29__net21 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__nm2 n13__i29__net29 n344__clk1pt6g i29__i134__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__nm3 i29__i134__net5 n4__i29__i134__x n253__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__nm0 n6__i29__i134__x n54__net23 i29__i134__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i134__nm1 i29__i134__net3 n3__i29__net17 n254__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i150__i0__nm0 n11__net41 n165__clk100m n6__i29__net30 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i150__i1__nm0 n6__i29__net30 n67__clk100m_b i29__net29 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__nm2 n13__i29__net16 n321__clk1pt6g i29__i133__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__nm3 i29__i133__net5 n4__i29__i133__x n255__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__nm0 n6__i29__i133__x n17__net23 i29__i133__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i133__nm1 i29__i133__net3 n3__i29__net10 n256__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i149__i0__nm0 n11__net40 n150__clk100m n6__i29__net17 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i149__i1__nm0 n6__i29__net17 n50__clk100m_b i29__net16 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__nm2 n13__i29__net9 n312__clk1pt6g i29__i132__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__nm3 i29__i132__net5 n4__i29__i132__x n257__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__nm0 n6__i29__i132__x n12__net23 i29__i132__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i132__nm1 i29__i132__net3 n3__i29__net20 n258__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i148__i0__nm0 n11__net39 n30__clk100m n6__i29__net10 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i148__i1__nm0 n6__i29__net10 n36__clk100m_b i29__net9 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__nm2 n13__i29__net19 n300__clk1pt6g i29__i131__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__nm3 i29__i131__net5 n4__i29__i131__x n259__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__nm0 n6__i29__i131__x n7__net23 i29__i131__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i131__nm1 i29__i131__net3 n3__i29__net27 n260__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i147__i0__nm0 n11__net38 n21__clk100m n6__i29__net20 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i147__i1__nm0 n6__i29__net20 n22__clk100m_b i29__net19 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__nm2 n13__i29__net26 n280__clk1pt6g i29__i130__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__nm3 i29__i130__net5 n4__i29__i130__x n261__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__nm0 n6__i29__i130__x n2__net23 i29__i130__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i130__nm1 i29__i130__net3 n3__net18 n262__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i146__i0__nm0 n11__net19 n13__clk100m n6__i29__net27 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i146__i1__nm0 n6__i29__net27 n14__clk100m_b i29__net26 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi37__nm0_1__rcx n4__net1 n4__net24 n383__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi37__nm0 n287__vss n3__net24 n4__net1 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_15__rcx n35__net23 n172__clk1pt6g n15__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_14__rcx n14__vss n180__clk1pt6g n35__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_13__rcx n33__net23 n184__clk1pt6g n14__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_12__rcx n13__vss n192__clk1pt6g n33__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_11__rcx n31__net23 n196__clk1pt6g n13__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_10__rcx n12__vss n204__clk1pt6g n31__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_9__rcx n29__net23 n208__clk1pt6g n12__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_8__rcx n1__vss n110__clk1pt6g n29__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_7__rcx n28__net23 n125__clk1pt6g n19__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_6__rcx n18__vss n132__clk1pt6g n28__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_5__rcx n41__net23 n136__clk1pt6g n18__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_4__rcx n17__vss n144__clk1pt6g n41__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_3__rcx n39__net23 n148__clk1pt6g n17__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_2__rcx n16__vss n156__clk1pt6g n39__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0_1__rcx n37__net23 n160__clk1pt6g n16__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0 n15__vss n168__clk1pt6g n37__net23 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_15__rcx n29__net22 n65__clk1pt6g n466__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_14__rcx n465__vss n73__clk1pt6g n29__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_13__rcx n27__net22 n77__clk1pt6g n465__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_12__rcx n464__vss n85__clk1pt6g n27__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_11__rcx n25__net22 n89__clk1pt6g n464__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_10__rcx n463__vss n97__clk1pt6g n25__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_9__rcx n23__net22 n101__clk1pt6g n463__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_8__rcx n462__vss n3__clk1pt6g n23__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_7__rcx n22__net22 n18__clk1pt6g n470__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_6__rcx n469__vss n25__clk1pt6g n22__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_5__rcx n35__net22 n29__clk1pt6g n469__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_4__rcx n468__vss n37__clk1pt6g n35__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_3__rcx n33__net22 n41__clk1pt6g n468__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_2__rcx n467__vss n49__clk1pt6g n33__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0_1__rcx n31__net22 n53__clk1pt6g n467__vss n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0 n466__vss n61__clk1pt6g n31__net22 n11__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.28e-6 PS=1.28e-6 NRD=1.16667 NRS=1.16667 M=1
mi36__nm0_1__rcx n11__net24 n4__net21 n381__vss n11__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi36__nm0 n382__vss n3__net21 n11__net24 n11__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi38__nm0 n10__net25 n5__ext_tx n328__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i1__nm0 n385__vss n3__net25 n5__net1 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i0__nm0 n5__net1 n7__ext_tx n2__net20 n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__nm2 n13__net21 n582__clk1pt6g i29__i161__net5 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__nm3 i29__i161__net5 n4__i29__i161__x n88__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__nm0 n6__i29__i161__x n153__net23 i29__i161__net3 n11__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i161__nm1 i29__i161__net3 n3__i29__net8 n232__vss n11__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
.END
