** Generated for: hspiceD
** Generated on: Dec  4 19:19:24 2023
** Design library name: ECE482final_cadence
** Design cell name: prbs
** Design view name: av_extracted

.TEMP 25.0
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2

** Library name: ECE482final_cadence
** Cell name: prbs
** View name: av_extracted
c1 vdd vss 18.1336e-18
c2 clk vss 140.054e-18
c3 clk_b vss 24.8327e-18
c4 rst vss 171.206e-18
c5 rst_b vss 48.1528e-18
c6 q0 vss 52.2619e-18
c7 q1 vss 54.358e-18
c8 q10 vss 54.8088e-18
c9 q11 vss 54.8145e-18
c10 q12 vss 54.4944e-18
c11 q13 vss 54.9863e-18
c12 q14 vss 54.9919e-18
c13 q15 vss 8.41203e-18
c14 q2 vss 54.8782e-18
c15 q3 vss 54.7215e-18
c16 q4 vss 54.7921e-18
c17 q5 vss 54.8088e-18
c18 q6 vss 64.0231e-18
c19 q7 vss 58.7103e-18
c20 q8 vss 54.7921e-18
c21 q9 vss 54.7921e-18
c22 d0 vss 92.1206e-18
c23 xor2 vss 64.7739e-18
c24 xor1 vss 20.5193e-18
c25 i58__net2 vss 54.7065e-18
c26 i58__net1 vss 30.7108e-18
c27 i56__net2 vss 36.8397e-18
c28 i56__net1 vss 30.1932e-18
c29 i57__net2 vss 49.675e-18
c30 i57__net1 vss 27.4291e-18
c31 i0__net2 vss 104.232e-18
c32 i0__x vss 47.6941e-18
c33 i0__net4 vss 93.4061e-18
c34 i0__net5 vss 98.5312e-18
c35 i0__net3 vss 105.768e-18
c36 i0__net1 vss 38.2329e-18
c37 i16__net2 vss 104.483e-18
c38 i16__x vss 47.7157e-18
c39 i16__net4 vss 93.1319e-18
c40 i16__net5 vss 99.4404e-18
c41 i16__net3 vss 105.768e-18
c42 i16__net1 vss 38.2233e-18
c43 i18__net2 vss 104.395e-18
c44 i18__x vss 47.7157e-18
c45 i18__net4 vss 93.1319e-18
c46 i18__net5 vss 99.4404e-18
c47 i18__net3 vss 105.768e-18
c48 i18__net1 vss 38.2237e-18
c49 i17__net2 vss 104.41e-18
c50 i17__x vss 48.4966e-18
c51 i17__net4 vss 94.7599e-18
c52 i17__net5 vss 99.4404e-18
c53 i17__net3 vss 105.778e-18
c54 i17__net1 vss 37.816e-18
c55 i22__net2 vss 105.884e-18
c56 i22__x vss 48.4966e-18
c57 i22__net4 vss 94.8443e-18
c58 i22__net5 vss 99.4404e-18
c59 i22__net3 vss 105.768e-18
c60 i22__net1 vss 37.771e-18
c61 i19__net2 vss 105.884e-18
c62 i19__x vss 48.4966e-18
c63 i19__net4 vss 94.8443e-18
c64 i19__net5 vss 99.4404e-18
c65 i19__net3 vss 105.768e-18
c66 i19__net1 vss 37.771e-18
c67 i21__net2 vss 105.884e-18
c68 i21__x vss 48.4966e-18
c69 i21__net4 vss 94.8443e-18
c70 i21__net5 vss 99.5189e-18
c71 i21__net3 vss 105.844e-18
c72 i21__net1 vss 37.771e-18
c73 i20__net2 vss 105.884e-18
c74 i20__x vss 48.4966e-18
c75 i20__net4 vss 94.8443e-18
c76 i20__net5 vss 99.4404e-18
c77 i20__net3 vss 105.768e-18
c78 i20__net1 vss 37.771e-18
c79 i30__net2 vss 105.884e-18
c80 i30__x vss 48.4966e-18
c81 i30__net4 vss 94.8443e-18
c82 i30__net5 vss 99.4404e-18
c83 i30__net3 vss 105.768e-18
c84 i30__net1 vss 37.771e-18
c85 i23__net2 vss 105.884e-18
c86 i23__x vss 48.4966e-18
c87 i23__net4 vss 94.8443e-18
c88 i23__net5 vss 99.4404e-18
c89 i23__net3 vss 105.768e-18
c90 i23__net1 vss 37.771e-18
c91 i25__net2 vss 105.884e-18
c92 i25__x vss 48.4966e-18
c93 i25__net4 vss 94.8443e-18
c94 i25__net5 vss 99.4404e-18
c95 i25__net3 vss 105.768e-18
c96 i25__net1 vss 37.7733e-18
c97 i24__net2 vss 105.884e-18
c98 i24__x vss 48.4966e-18
c99 i24__net4 vss 94.8443e-18
c100 i24__net5 vss 99.4404e-18
c101 i24__net3 vss 105.649e-18
c102 i24__net1 vss 37.771e-18
c103 i29__net2 vss 104.513e-18
c104 i29__x vss 48.1731e-18
c105 i29__net4 vss 93.7422e-18
c106 i29__net5 vss 100.648e-18
c107 i29__net3 vss 108.099e-18
c108 i29__net1 vss 37.771e-18
c109 i26__net2 vss 104.513e-18
c110 i26__x vss 48.1731e-18
c111 i26__net4 vss 93.7422e-18
c112 i26__net5 vss 100.841e-18
c113 i26__net3 vss 108.505e-18
c114 i26__net1 vss 37.771e-18
c115 i28__net2 vss 103.942e-18
c116 i28__x vss 48.2468e-18
c117 i28__net4 vss 93.2792e-18
c118 i28__net5 vss 101.982e-18
c119 i28__net3 vss 108.178e-18
c120 i28__net1 vss 38.0695e-18
c121 i27__net2 vss 102.5e-18
c122 i27__x vss 48.3833e-18
c123 i27__net4 vss 91.3004e-18
c124 i27__net5 vss 100.346e-18
c125 i27__net3 vss 108.392e-18
c126 i27__net1 vss 38.7947e-18
c127 n153__clk_b vss 29.3367e-18
c128 n131__rst_b vss 31.6762e-18
c129 n202__rst vss 34.8207e-18
c130 n133__clk vss 29.4339e-18
c131 n142__clk_b vss 31.035e-18
c132 n121__rst_b vss 30.2734e-18
c133 n186__rst vss 34.732e-18
c134 n123__clk vss 29.8409e-18
c135 n131__clk_b vss 31.0295e-18
c136 n111__rst_b vss 30.2734e-18
c137 n170__rst vss 34.732e-18
c138 n112__clk vss 29.8409e-18
c139 n118__clk_b vss 31.9853e-18
c140 n101__rst_b vss 30.2734e-18
c141 n154__rst vss 34.732e-18
c142 n102__clk vss 30.6127e-18
c143 n107__clk_b vss 31.9788e-18
c144 n91__rst_b vss 30.2734e-18
c145 n138__rst vss 34.732e-18
c146 n92__clk vss 30.8035e-18
c147 n96__clk_b vss 31.9788e-18
c148 n81__rst_b vss 30.2734e-18
c149 n122__rst vss 34.732e-18
c150 n82__clk vss 30.8035e-18
c151 n85__clk_b vss 31.9788e-18
c152 n71__rst_b vss 30.2734e-18
c153 n106__rst vss 34.732e-18
c154 n72__clk vss 30.8035e-18
c155 n74__clk_b vss 31.9788e-18
c156 n61__rst_b vss 30.2734e-18
c157 n90__rst vss 34.732e-18
c158 n62__clk vss 30.8035e-18
c159 n63__clk_b vss 31.9788e-18
c160 n51__rst_b vss 30.2734e-18
c161 n74__rst vss 34.732e-18
c162 n52__clk vss 30.8035e-18
c163 n52__clk_b vss 31.9788e-18
c164 n41__rst_b vss 30.2734e-18
c165 n58__rst vss 34.732e-18
c166 n42__clk vss 30.8035e-18
c167 n41__clk_b vss 31.9788e-18
c168 n31__rst_b vss 30.2734e-18
c169 n42__rst vss 34.732e-18
c170 n32__clk vss 30.8035e-18
c171 n30__clk_b vss 31.9788e-18
c172 n21__rst_b vss 30.2734e-18
c173 n26__rst vss 34.732e-18
c174 n22__clk vss 30.8035e-18
c175 n19__clk_b vss 31.4737e-18
c176 n11__rst_b vss 30.2734e-18
c177 n16__rst vss 34.732e-18
c178 n16__clk vss 30.4162e-18
c179 n14__clk_b vss 31.4737e-18
c180 n8__rst_b vss 30.2734e-18
c181 n11__rst vss 34.732e-18
c182 n11__clk vss 30.3614e-18
c183 n9__clk_b vss 31.472e-18
c184 n5__rst_b vss 30.2734e-18
c185 n6__rst vss 34.7035e-18
c186 n6__clk vss 30.3646e-18
c187 n4__clk_b vss 31.2251e-18
c188 n2__rst_b vss 30.4208e-18
c189 n1__rst vss 36.446e-18
c190 n1__clk vss 30.1299e-18
c191 n9__xor2 vss 31.7986e-18
c192 n3__xor2 vss 38.3714e-18
c193 n4__xor1 vss 24.205e-18
c194 n4__q14 vss 25.7027e-18
c195 n7__q15 vss 34.0688e-18
c196 n3__q12 vss 27.8556e-18
c197 n6__i57__net1 vss 30.7454e-18
c198 n9__q3 vss 40.5841e-18
c199 n1__q15 vss 31.8898e-18
c200 n1__q3 vss 31.8153e-18
c201 n140__clk vss 16.5712e-18
c202 n4__i0__x vss 33.2213e-18
c203 n130__rst_b vss 40.4663e-18
c204 n205__rst vss 22.2048e-18
c205 n150__clk_b vss 17.7447e-18
c206 n3__i0__net1 vss 36.4334e-18
c207 n130__clk vss 17.2089e-18
c208 n4__i16__x vss 33.02e-18
c209 n120__rst_b vss 42.3618e-18
c210 n189__rst vss 22.4616e-18
c211 n139__clk_b vss 17.7474e-18
c212 n3__i16__net1 vss 36.4478e-18
c213 n120__clk vss 17.2049e-18
c214 n4__i18__x vss 33.02e-18
c215 n110__rst_b vss 42.3615e-18
c216 n173__rst vss 22.4511e-18
c217 n128__clk_b vss 17.7474e-18
c218 n3__i18__net1 vss 36.4478e-18
c219 n109__clk vss 17.2049e-18
c220 n4__i17__x vss 33.02e-18
c221 n100__rst_b vss 42.3615e-18
c222 n157__rst vss 22.4511e-18
c223 n115__clk_b vss 17.7474e-18
c224 n3__i17__net1 vss 36.4478e-18
c225 n99__clk vss 17.2049e-18
c226 n4__i22__x vss 33.02e-18
c227 n90__rst_b vss 42.3615e-18
c228 n141__rst vss 22.4511e-18
c229 n104__clk_b vss 17.7474e-18
c230 n3__i22__net1 vss 36.4478e-18
c231 n89__clk vss 17.2049e-18
c232 n4__i19__x vss 33.02e-18
c233 n80__rst_b vss 42.3615e-18
c234 n125__rst vss 22.4511e-18
c235 n93__clk_b vss 17.7474e-18
c236 n3__i19__net1 vss 36.4478e-18
c237 n79__clk vss 17.2049e-18
c238 n4__i21__x vss 33.02e-18
c239 n70__rst_b vss 42.3615e-18
c240 n109__rst vss 22.4511e-18
c241 n82__clk_b vss 17.7474e-18
c242 n3__i21__net1 vss 36.4478e-18
c243 n69__clk vss 17.2049e-18
c244 n4__i20__x vss 33.02e-18
c245 n60__rst_b vss 42.3615e-18
c246 n93__rst vss 22.4511e-18
c247 n71__clk_b vss 17.7474e-18
c248 n3__i20__net1 vss 36.4478e-18
c249 n59__clk vss 17.2049e-18
c250 n4__i30__x vss 33.02e-18
c251 n50__rst_b vss 42.3615e-18
c252 n77__rst vss 22.4511e-18
c253 n60__clk_b vss 17.7474e-18
c254 n3__i30__net1 vss 36.4478e-18
c255 n49__clk vss 17.2049e-18
c256 n4__i23__x vss 33.02e-18
c257 n40__rst_b vss 42.3615e-18
c258 n61__rst vss 22.4511e-18
c259 n49__clk_b vss 17.7474e-18
c260 n3__i23__net1 vss 36.4478e-18
c261 n39__clk vss 17.2049e-18
c262 n4__i25__x vss 33.02e-18
c263 n30__rst_b vss 42.3615e-18
c264 n45__rst vss 22.4511e-18
c265 n38__clk_b vss 17.7474e-18
c266 n3__i25__net1 vss 36.4478e-18
c267 n29__clk vss 17.2049e-18
c268 n4__i24__x vss 32.8994e-18
c269 n20__rst_b vss 42.3615e-18
c270 n29__rst vss 22.4511e-18
c271 n27__clk_b vss 17.7474e-18
c272 n3__i24__net1 vss 36.38e-18
c273 n19__clk vss 17.4686e-18
c274 n4__i29__x vss 32.5761e-18
c275 n10__rst_b vss 42.3615e-18
c276 n19__rst vss 22.4511e-18
c277 n17__clk_b vss 17.1404e-18
c278 n3__i29__net1 vss 36.1469e-18
c279 n14__clk vss 17.4627e-18
c280 n4__i26__x vss 32.5761e-18
c281 n7__rst_b vss 42.3594e-18
c282 n14__rst vss 22.4511e-18
c283 n12__clk_b vss 17.1404e-18
c284 n3__i26__net1 vss 36.0537e-18
c285 n9__clk vss 17.469e-18
c286 n4__i28__x vss 33.0409e-18
c287 n4__rst_b vss 42.3594e-18
c288 n9__rst vss 22.4511e-18
c289 n7__clk_b vss 17.6808e-18
c290 n3__i28__net1 vss 37.4851e-18
c291 n4__clk vss 17.8417e-18
c292 n4__i27__x vss 33.5851e-18
c293 n1__rst_b vss 42.4057e-18
c294 n4__rst vss 24.0022e-18
c295 n2__clk_b vss 18.0401e-18
c296 n3__i27__net1 vss 34.8065e-18
c297 n5__i56__net1 vss 28.0791e-18
c298 n7__xor2 vss 24.2692e-18
c299 n2__xor2 vss 15.293e-18
c300 n3__q14 vss 21.8894e-18
c301 n8__q15 vss 15.1051e-18
c302 n4__q12 vss 19.353e-18
c303 n6__q15 vss 24.274e-18
c304 n7__q3 vss 19.6256e-18
c305 n5__q3 vss 24.0231e-18
c306 n4__i58__net1 vss 27.1324e-18
c307 n154__clk_b vss 31.797e-18
c308 n139__clk vss 28.5092e-18
c309 n141__clk vss 24.0303e-18
c310 n132__rst_b vss 30.741e-18
c311 n3__i0__x vss 39.9713e-18
c312 n206__rst vss 165.832e-18
c313 n204__rst vss 7.94974e-18
c314 n134__clk vss 31.7017e-18
c315 n149__clk_b vss 130.284e-18
c316 n151__clk_b vss 23.5163e-18
c317 n2__i0__net1 vss 70.7577e-18
c318 n143__clk_b vss 31.9215e-18
c319 n129__clk vss 29.2321e-18
c320 n131__clk vss 22.9719e-18
c321 n122__rst_b vss 29.2704e-18
c322 n3__i16__x vss 39.8907e-18
c323 n190__rst vss 281.576e-18
c324 n188__rst vss 7.94946e-18
c325 n124__clk vss 31.7179e-18
c326 n138__clk_b vss 130.27e-18
c327 n140__clk_b vss 23.5097e-18
c328 n2__i16__net1 vss 70.708e-18
c329 n132__clk_b vss 31.8646e-18
c330 n119__clk vss 29.2321e-18
c331 n121__clk vss 22.9719e-18
c332 n112__rst_b vss 29.2704e-18
c333 n3__i18__x vss 39.8907e-18
c334 n174__rst vss 281.552e-18
c335 n172__rst vss 7.94946e-18
c336 n113__clk vss 31.7694e-18
c337 n127__clk_b vss 130.27e-18
c338 n129__clk_b vss 23.5097e-18
c339 n2__i18__net1 vss 70.708e-18
c340 n119__clk_b vss 31.8646e-18
c341 n108__clk vss 29.226e-18
c342 n110__clk vss 22.9609e-18
c343 n102__rst_b vss 29.2704e-18
c344 n3__i17__x vss 39.8907e-18
c345 n158__rst vss 281.552e-18
c346 n156__rst vss 7.94946e-18
c347 n103__clk vss 31.7694e-18
c348 n114__clk_b vss 130.263e-18
c349 n116__clk_b vss 23.5131e-18
c350 n2__i17__net1 vss 70.505e-18
c351 n108__clk_b vss 31.9215e-18
c352 n98__clk vss 29.226e-18
c353 n100__clk vss 22.9749e-18
c354 n92__rst_b vss 113.287e-18
c355 n3__i22__x vss 39.8907e-18
c356 n142__rst vss 281.552e-18
c357 n140__rst vss 7.94946e-18
c358 n93__clk vss 31.7179e-18
c359 n103__clk_b vss 130.263e-18
c360 n105__clk_b vss 23.499e-18
c361 n2__i22__net1 vss 70.505e-18
c362 n97__clk_b vss 31.9215e-18
c363 n88__clk vss 29.226e-18
c364 n90__clk vss 22.9719e-18
c365 n82__rst_b vss 29.2704e-18
c366 n3__i19__x vss 39.8907e-18
c367 n126__rst vss 281.552e-18
c368 n124__rst vss 7.94946e-18
c369 n83__clk vss 31.7179e-18
c370 n92__clk_b vss 130.263e-18
c371 n94__clk_b vss 23.5097e-18
c372 n2__i19__net1 vss 70.505e-18
c373 n86__clk_b vss 31.9215e-18
c374 n78__clk vss 29.226e-18
c375 n80__clk vss 22.8504e-18
c376 n72__rst_b vss 29.2704e-18
c377 n3__i21__x vss 39.8892e-18
c378 n110__rst vss 281.552e-18
c379 n108__rst vss 7.94946e-18
c380 n73__clk vss 31.7179e-18
c381 n81__clk_b vss 130.263e-18
c382 n83__clk_b vss 23.3382e-18
c383 n2__i21__net1 vss 70.4983e-18
c384 n75__clk_b vss 31.9215e-18
c385 n68__clk vss 29.226e-18
c386 n70__clk vss 22.9861e-18
c387 n62__rst_b vss 29.2704e-18
c388 n3__i20__x vss 39.8907e-18
c389 n94__rst vss 281.552e-18
c390 n92__rst vss 7.94946e-18
c391 n63__clk vss 31.7179e-18
c392 n70__clk_b vss 130.263e-18
c393 n72__clk_b vss 23.5302e-18
c394 n2__i20__net1 vss 70.505e-18
c395 n64__clk_b vss 31.9215e-18
c396 n58__clk vss 29.226e-18
c397 n60__clk vss 22.9926e-18
c398 n52__rst_b vss 29.2704e-18
c399 n3__i30__x vss 39.8907e-18
c400 n78__rst vss 281.678e-18
c401 n76__rst vss 7.94946e-18
c402 n53__clk vss 31.7179e-18
c403 n59__clk_b vss 130.263e-18
c404 n61__clk_b vss 23.5302e-18
c405 n2__i30__net1 vss 70.505e-18
c406 n53__clk_b vss 31.9215e-18
c407 n48__clk vss 29.226e-18
c408 n50__clk vss 22.9749e-18
c409 n42__rst_b vss 29.2704e-18
c410 n3__i23__x vss 39.8907e-18
c411 n62__rst vss 281.552e-18
c412 n60__rst vss 7.94946e-18
c413 n43__clk vss 31.7179e-18
c414 n48__clk_b vss 130.263e-18
c415 n50__clk_b vss 23.499e-18
c416 n2__i23__net1 vss 70.505e-18
c417 n42__clk_b vss 31.9215e-18
c418 n38__clk vss 29.226e-18
c419 n40__clk vss 22.9719e-18
c420 n32__rst_b vss 29.2704e-18
c421 n3__i25__x vss 39.8907e-18
c422 n46__rst vss 281.552e-18
c423 n44__rst vss 7.94946e-18
c424 n33__clk vss 31.7179e-18
c425 n37__clk_b vss 130.263e-18
c426 n39__clk_b vss 23.5097e-18
c427 n2__i25__net1 vss 70.506e-18
c428 n31__clk_b vss 31.9215e-18
c429 n28__clk vss 29.226e-18
c430 n30__clk vss 22.9719e-18
c431 n22__rst_b vss 29.2704e-18
c432 n3__i24__x vss 39.8907e-18
c433 n30__rst vss 281.552e-18
c434 n28__rst vss 7.94946e-18
c435 n23__clk vss 31.7179e-18
c436 n26__clk_b vss 130.265e-18
c437 n28__clk_b vss 23.5097e-18
c438 n2__i24__net1 vss 70.505e-18
c439 n20__clk_b vss 31.9215e-18
c440 n18__clk vss 29.2201e-18
c441 n20__clk vss 22.9694e-18
c442 n12__rst_b vss 29.2704e-18
c443 n3__i29__x vss 39.8684e-18
c444 n20__rst vss 281.552e-18
c445 n18__rst vss 7.94946e-18
c446 n17__clk vss 31.7179e-18
c447 n16__clk_b vss 130.304e-18
c448 n18__clk_b vss 23.5023e-18
c449 n2__i29__net1 vss 70.3492e-18
c450 n15__clk_b vss 31.9215e-18
c451 n13__clk vss 29.1448e-18
c452 n15__clk vss 22.9694e-18
c453 n9__rst_b vss 29.2704e-18
c454 n3__i26__x vss 39.8684e-18
c455 n15__rst vss 281.552e-18
c456 n13__rst vss 7.94946e-18
c457 n12__clk vss 31.7179e-18
c458 n11__clk_b vss 130.278e-18
c459 n13__clk_b vss 23.5023e-18
c460 n2__i26__net1 vss 70.3843e-18
c461 n10__clk_b vss 31.9215e-18
c462 n8__clk vss 29.1919e-18
c463 n10__clk vss 22.9739e-18
c464 n6__rst_b vss 29.2408e-18
c465 n3__i28__x vss 39.7438e-18
c466 n10__rst vss 280.139e-18
c467 n8__rst vss 7.94143e-18
c468 n7__clk vss 32.3744e-18
c469 n6__clk_b vss 131.981e-18
c470 n8__clk_b vss 23.4998e-18
c471 n2__i28__net1 vss 72.281e-18
c472 n5__clk_b vss 31.8697e-18
c473 n3__clk vss 29.7671e-18
c474 n5__clk vss 23.6027e-18
c475 n3__rst_b vss 30.8088e-18
c476 n3__i27__x vss 39.4349e-18
c477 n3__rst vss 8.91611e-18
c478 n2__clk vss 32.1227e-18
c479 n1__clk_b vss 126.731e-18
c480 n3__clk_b vss 24.5386e-18
c481 n2__i27__net1 vss 71.1649e-18
c482 n8__xor2 vss 27.8393e-18
c483 n3__i56__net1 vss 12.4088e-18
c484 n2__i56__net1 vss 29.289e-18
c485 n6__xor2 vss 10.4355e-18
c486 n1__q14 vss 11.2779e-18
c487 n3__xor1 vss 12.0719e-18
c488 n1__q12 vss 10.7692e-18
c489 n9__q15 vss 52.6995e-18
c490 n3__q15 vss 9.77447e-18
c491 n5__i57__net1 vss 28.4325e-18
c492 n8__q3 vss 56.9782e-18
c493 n3__i57__net1 vss 35.3416e-18
c494 n2__q15 vss 27.6922e-18
c495 n3__q3 vss 52.985e-18
c496 n5__i58__net1 vss 23.3521e-18
c497 n3__i58__net1 vss 53.44e-18
c498 n2__q3 vss 24.6685e-18
c499 n160__rst_b vss 50.3354e-18
c500 n159__rst_b vss 85.3834e-18
c501 n158__rst_b vss 85.3834e-18
c502 n31__q3 vss 830.909e-18
c503 n157__rst_b vss 97.0431e-18
c504 n123__rst_b vss 100.104e-18
c505 n113__rst_b vss 100.104e-18
c506 n103__rst_b vss 100.104e-18
c507 n93__rst_b vss 100.104e-18
c508 n83__rst_b vss 100.729e-18
c509 n73__rst_b vss 100.104e-18
c510 n63__rst_b vss 99.9168e-18
c511 n53__rst_b vss 100.104e-18
c512 n43__rst_b vss 101.615e-18
c513 n33__rst_b vss 101.265e-18
c514 n23__rst_b vss 102.766e-18
c515 n13__rst_b vss 15.3082e-18
c516 n13__q3 vss 697.306e-18
c517 n156__rst_b vss 79.5163e-18
c518 n178__clk_b vss 47.9047e-18
c519 n16__q0 vss 98.4096e-18
c520 n16__q1 vss 146.191e-18
c521 n155__rst_b vss 88.1008e-18
c522 n177__clk_b vss 77.6248e-18
c523 n15__q1 vss 119.721e-18
c524 n16__q2 vss 148.417e-18
c525 n154__rst_b vss 88.1008e-18
c526 n176__clk_b vss 76.1393e-18
c527 n15__q2 vss 119.299e-18
c528 n30__q3 vss 59.6865e-18
c529 n153__rst_b vss 89.1518e-18
c530 n175__clk_b vss 79.5517e-18
c531 n23__q3 vss 94.3849e-18
c532 n12__q4 vss 167.2e-18
c533 n124__rst_b vss 89.1518e-18
c534 n147__clk_b vss 79.5301e-18
c535 n10__q4 vss 125.545e-18
c536 n12__q5 vss 166.211e-18
c537 n114__rst_b vss 89.1518e-18
c538 n136__clk_b vss 79.5299e-18
c539 n10__q5 vss 125.57e-18
c540 n12__q6 vss 166.211e-18
c541 n104__rst_b vss 89.1518e-18
c542 n125__clk_b vss 79.365e-18
c543 n10__q6 vss 125.57e-18
c544 n12__q7 vss 166.211e-18
c545 n94__rst_b vss 89.1518e-18
c546 n112__clk_b vss 79.5301e-18
c547 n10__q7 vss 125.57e-18
c548 n12__q8 vss 166.211e-18
c549 n84__rst_b vss 89.1518e-18
c550 n101__clk_b vss 79.5301e-18
c551 n10__q8 vss 125.57e-18
c552 n12__q9 vss 166.211e-18
c553 n74__rst_b vss 89.1518e-18
c554 n90__clk_b vss 79.5301e-18
c555 n10__q9 vss 125.57e-18
c556 n12__q10 vss 166.211e-18
c557 n64__rst_b vss 89.1518e-18
c558 n79__clk_b vss 79.8792e-18
c559 n10__q10 vss 125.562e-18
c560 n12__q11 vss 166.211e-18
c561 n54__rst_b vss 89.1518e-18
c562 n68__clk_b vss 86.7252e-18
c563 n10__q11 vss 125.585e-18
c564 n24__q12 vss 614.218e-18
c565 n44__rst_b vss 90.0043e-18
c566 n57__clk_b vss 136.787e-18
c567 n22__q12 vss 124.391e-18
c568 n12__q13 vss 176.846e-18
c569 n34__rst_b vss 90.0043e-18
c570 n46__clk_b vss 136.994e-18
c571 n10__q13 vss 128.073e-18
c572 n29__q14 vss 327.544e-18
c573 n24__rst_b vss 89.6991e-18
c574 n35__clk_b vss 114.337e-18
c575 n23__q14 vss 120.93e-18
c576 n14__rst_b vss 66.2624e-18
c577 n24__clk_b vss 61.2242e-18
c578 n18__xor1 vss 60.9519e-18
c579 n10__q14 vss 224.44e-18
c580 n13__xor1 vss 128.773e-18
c581 n12__q12 vss 440.702e-18
c582 n9__q14 vss 53.9628e-18
c583 n10__xor1 vss 98.6327e-18
c584 n12__q3 vss 13.5461e-18
c585 n9__q12 vss 127.241e-18
c586 n15__q0 vss 23.8288e-18
c587 n161__clk vss 52.6743e-18
c588 n256__rst vss 48.6483e-18
c589 n152__rst_b vss 35.7785e-18
c590 n12__i0__net1 vss 129.552e-18
c591 n255__rst vss 51.6991e-18
c592 n174__clk_b vss 100.79e-18
c593 n11__i0__net1 vss 125.258e-18
c594 n12__q0 vss 26.8766e-18
c595 n14__q1 vss 51.8878e-18
c596 n160__clk vss 11.3575e-18
c597 n254__rst vss 60.4791e-18
c598 n149__rst_b vss 35.5548e-18
c599 n12__i16__net1 vss 131.262e-18
c600 n253__rst vss 55.7321e-18
c601 n173__clk_b vss 100.383e-18
c602 n11__i16__net1 vss 126.993e-18
c603 n12__q1 vss 26.8524e-18
c604 n14__q2 vss 52.4529e-18
c605 n159__clk vss 11.3575e-18
c606 n252__rst vss 60.4791e-18
c607 n146__rst_b vss 35.5548e-18
c608 n12__i18__net1 vss 131.262e-18
c609 n251__rst vss 55.7321e-18
c610 n172__clk_b vss 100.383e-18
c611 n11__i18__net1 vss 125.817e-18
c612 n12__q2 vss 26.7797e-18
c613 n29__q3 vss 51.4757e-18
c614 n158__clk vss 11.993e-18
c615 n250__rst vss 60.5956e-18
c616 n143__rst_b vss 35.5548e-18
c617 n12__i17__net1 vss 131.069e-18
c618 n249__rst vss 55.3995e-18
c619 n171__clk_b vss 100.801e-18
c620 n11__i17__net1 vss 128.541e-18
c621 n21__q3 vss 26.7869e-18
c622 n11__q4 vss 51.4615e-18
c623 n138__clk vss 11.993e-18
c624 n207__rst vss 60.5956e-18
c625 n129__rst_b vss 35.5548e-18
c626 n12__i22__net1 vss 131.03e-18
c627 n200__rst vss 55.3938e-18
c628 n146__clk_b vss 100.801e-18
c629 n5__i22__net1 vss 128.002e-18
c630 n9__q4 vss 26.7869e-18
c631 n11__q5 vss 51.4615e-18
c632 n128__clk vss 11.993e-18
c633 n191__rst vss 60.5956e-18
c634 n119__rst_b vss 35.5548e-18
c635 n12__i19__net1 vss 131.03e-18
c636 n184__rst vss 55.3938e-18
c637 n135__clk_b vss 100.92e-18
c638 n5__i19__net1 vss 128.002e-18
c639 n9__q5 vss 26.7869e-18
c640 n11__q6 vss 51.4615e-18
c641 n118__clk vss 51.6849e-18
c642 n175__rst vss 60.5956e-18
c643 n109__rst_b vss 35.5548e-18
c644 n12__i21__net1 vss 131.03e-18
c645 n168__rst vss 55.3938e-18
c646 n124__clk_b vss 52.8261e-18
c647 n5__i21__net1 vss 128.002e-18
c648 n9__q6 vss 26.7869e-18
c649 n11__q7 vss 51.4615e-18
c650 n107__clk vss 12.2341e-18
c651 n159__rst vss 60.5956e-18
c652 n99__rst_b vss 35.5548e-18
c653 n12__i20__net1 vss 131.03e-18
c654 n152__rst vss 55.3938e-18
c655 n111__clk_b vss 100.801e-18
c656 n5__i20__net1 vss 128.002e-18
c657 n9__q7 vss 26.7869e-18
c658 n11__q8 vss 51.4615e-18
c659 n97__clk vss 11.993e-18
c660 n143__rst vss 61.017e-18
c661 n89__rst_b vss 35.5548e-18
c662 n12__i30__net1 vss 131.03e-18
c663 n136__rst vss 55.3938e-18
c664 n100__clk_b vss 100.801e-18
c665 n5__i30__net1 vss 128.002e-18
c666 n9__q8 vss 26.7869e-18
c667 n11__q9 vss 51.4615e-18
c668 n87__clk vss 11.993e-18
c669 n127__rst vss 60.5956e-18
c670 n79__rst_b vss 35.5548e-18
c671 n12__i23__net1 vss 131.03e-18
c672 n120__rst vss 55.3938e-18
c673 n89__clk_b vss 100.801e-18
c674 n5__i23__net1 vss 128.002e-18
c675 n9__q9 vss 26.7869e-18
c676 n11__q10 vss 51.4615e-18
c677 n77__clk vss 11.993e-18
c678 n111__rst vss 60.5956e-18
c679 n69__rst_b vss 35.5548e-18
c680 n12__i25__net1 vss 131.027e-18
c681 n104__rst vss 55.3938e-18
c682 n78__clk_b vss 100.821e-18
c683 n5__i25__net1 vss 128.071e-18
c684 n9__q10 vss 26.7869e-18
c685 n11__q11 vss 51.4615e-18
c686 n67__clk vss 12.0552e-18
c687 n95__rst vss 60.5956e-18
c688 n59__rst_b vss 35.5548e-18
c689 n12__i24__net1 vss 131.03e-18
c690 n88__rst vss 55.3938e-18
c691 n67__clk_b vss 100.925e-18
c692 n5__i24__net1 vss 128.071e-18
c693 n9__q11 vss 26.7886e-18
c694 n23__q12 vss 51.4091e-18
c695 n57__clk vss 13.8222e-18
c696 n79__rst vss 60.5956e-18
c697 n49__rst_b vss 35.7195e-18
c698 n12__i29__net1 vss 131.025e-18
c699 n72__rst vss 55.3938e-18
c700 n56__clk_b vss 103.997e-18
c701 n5__i29__net1 vss 129.326e-18
c702 n21__q12 vss 26.7783e-18
c703 n11__q13 vss 51.4091e-18
c704 n47__clk vss 14.2935e-18
c705 n63__rst vss 60.5966e-18
c706 n39__rst_b vss 35.7195e-18
c707 n12__i26__net1 vss 131.03e-18
c708 n56__rst vss 55.4131e-18
c709 n45__clk_b vss 103.998e-18
c710 n5__i26__net1 vss 129.326e-18
c711 n9__q13 vss 25.7728e-18
c712 n28__q14 vss 51.5502e-18
c713 n37__clk vss 18.3342e-18
c714 n47__rst vss 60.7656e-18
c715 n29__rst_b vss 36.2415e-18
c716 n12__i28__net1 vss 130.479e-18
c717 n40__rst vss 54.7168e-18
c718 n34__clk_b vss 113.107e-18
c719 n5__i28__net1 vss 88.6575e-18
c720 n22__q14 vss 24.0546e-18
c721 n27__clk vss 18.9781e-18
c722 n31__rst vss 59.8078e-18
c723 n19__rst_b vss 38.9163e-18
c724 n12__i27__net1 vss 119.941e-18
c725 n24__rst vss 49.4627e-18
c726 n23__clk_b vss 124.037e-18
c727 n5__i27__net1 vss 91.068e-18
c728 n17__xor1 vss 60.6452e-18
c729 n16__i56__net1 vss 173.976e-18
c730 n13__q14 vss 267.932e-18
c731 n12__i56__net1 vss 154.072e-18
c732 n8__i56__net2 vss 62.6922e-18
c733 n4__i56__net2 vss 58.5978e-18
c734 n12__xor1 vss 38.7467e-18
c735 n8__i57__net2 vss 117.765e-18
c736 n11__q12 vss 36.1695e-18
c737 n8__i58__net2 vss 108.885e-18
c738 n4__i57__net2 vss 60.4804e-18
c739 n13__i57__net1 vss 137.715e-18
c740 n10__i57__net1 vss 90.0663e-18
c741 n8__q14 vss 122.06e-18
c742 n4__i58__net2 vss 64.0809e-18
c743 n11__i58__net1 vss 148.813e-18
c744 n9__xor1 vss 29.8125e-18
c745 n7__i58__net1 vss 166.445e-18
c746 n10__q0 vss 102.987e-18
c747 n247__rst vss 115.383e-18
c748 n170__clk_b vss 147.114e-18
c749 n155__clk vss 189.633e-18
c750 n156__clk vss 99.178e-18
c751 n10__d0 vss 1.39382e-15
c752 n244__rst vss 133.274e-18
c753 n140__rst_b vss 126.407e-18
c754 n9__i0__net1 vss 200.484e-18
c755 n243__rst vss 156.435e-18
c756 n242__rst vss 150.073e-18
c757 n8__d0 vss 122.344e-18
c758 n169__clk_b vss 80.8965e-18
c759 n154__clk vss 263.468e-18
c760 n167__clk_b vss 81.825e-18
c761 n5__i0__net1 vss 90.7827e-18
c762 n10__q1 vss 180.474e-18
c763 n6__q0 vss 110.415e-18
c764 n238__rst vss 135.414e-18
c765 n166__clk_b vss 146.007e-18
c766 n151__clk vss 193.391e-18
c767 n152__clk vss 100.443e-18
c768 n7__q0 vss 205.054e-18
c769 n235__rst vss 132.859e-18
c770 n138__rst_b vss 127.736e-18
c771 n9__i16__net1 vss 200.596e-18
c772 n234__rst vss 156.114e-18
c773 n233__rst vss 151.056e-18
c774 n4__q0 vss 127.493e-18
c775 n165__clk_b vss 80.8901e-18
c776 n150__clk vss 263.258e-18
c777 n163__clk_b vss 81.6687e-18
c778 n5__i16__net1 vss 90.8852e-18
c779 n10__q2 vss 180.566e-18
c780 n6__q1 vss 110.364e-18
c781 n229__rst vss 135.414e-18
c782 n162__clk_b vss 146.007e-18
c783 n147__clk vss 193.391e-18
c784 n148__clk vss 100.443e-18
c785 n7__q1 vss 205.054e-18
c786 n226__rst vss 132.838e-18
c787 n136__rst_b vss 127.736e-18
c788 n9__i18__net1 vss 200.596e-18
c789 n225__rst vss 156.114e-18
c790 n224__rst vss 151.056e-18
c791 n4__q1 vss 127.493e-18
c792 n161__clk_b vss 80.8901e-18
c793 n146__clk vss 263.258e-18
c794 n159__clk_b vss 81.6687e-18
c795 n5__i18__net1 vss 90.8852e-18
c796 n26__q3 vss 180.561e-18
c797 n6__q2 vss 110.363e-18
c798 n220__rst vss 135.449e-18
c799 n158__clk_b vss 145.663e-18
c800 n143__clk vss 191.342e-18
c801 n144__clk vss 100.948e-18
c802 n7__q2 vss 205.054e-18
c803 n217__rst vss 132.903e-18
c804 n134__rst_b vss 127.736e-18
c805 n9__i17__net1 vss 200.596e-18
c806 n216__rst vss 156.114e-18
c807 n215__rst vss 151.158e-18
c808 n4__q2 vss 127.494e-18
c809 n157__clk_b vss 80.5214e-18
c810 n142__clk vss 260.421e-18
c811 n155__clk_b vss 81.6687e-18
c812 n5__i17__net1 vss 90.7827e-18
c813 n13__q4 vss 180.562e-18
c814 n22__q3 vss 110.364e-18
c815 n211__rst vss 135.414e-18
c816 n152__clk_b vss 145.663e-18
c817 n135__clk vss 191.816e-18
c818 n136__clk vss 100.948e-18
c819 n20__q3 vss 205.054e-18
c820 n208__rst vss 132.933e-18
c821 n126__rst_b vss 43.7194e-18
c822 n10__i22__net1 vss 200.596e-18
c823 n201__rst vss 156.114e-18
c824 n199__rst vss 151.056e-18
c825 n18__q3 vss 127.493e-18
c826 n148__clk_b vss 80.5709e-18
c827 n132__clk vss 260.604e-18
c828 n144__clk_b vss 81.6687e-18
c829 n4__i22__net1 vss 90.7827e-18
c830 n14__q5 vss 180.566e-18
c831 n7__q4 vss 110.364e-18
c832 n195__rst vss 135.414e-18
c833 n141__clk_b vss 145.663e-18
c834 n125__clk vss 191.816e-18
c835 n126__clk vss 100.948e-18
c836 n6__q4 vss 205.054e-18
c837 n192__rst vss 132.933e-18
c838 n116__rst_b vss 127.736e-18
c839 n10__i19__net1 vss 200.596e-18
c840 n185__rst vss 156.114e-18
c841 n183__rst vss 151.056e-18
c842 n4__q4 vss 127.493e-18
c843 n137__clk_b vss 80.5709e-18
c844 n122__clk vss 260.604e-18
c845 n133__clk_b vss 81.72e-18
c846 n4__i19__net1 vss 90.7827e-18
c847 n14__q6 vss 180.566e-18
c848 n7__q5 vss 110.364e-18
c849 n179__rst vss 135.414e-18
c850 n130__clk_b vss 145.663e-18
c851 n114__clk vss 191.708e-18
c852 n115__clk vss 80.0017e-18
c853 n6__q5 vss 205.054e-18
c854 n176__rst vss 132.933e-18
c855 n106__rst_b vss 127.736e-18
c856 n10__i21__net1 vss 200.596e-18
c857 n169__rst vss 156.114e-18
c858 n167__rst vss 151.056e-18
c859 n4__q5 vss 127.493e-18
c860 n126__clk_b vss 80.5709e-18
c861 n111__clk vss 260.258e-18
c862 n120__clk_b vss 124.743e-18
c863 n4__i21__net1 vss 90.7827e-18
c864 n14__q7 vss 180.605e-18
c865 n7__q6 vss 110.364e-18
c866 n163__rst vss 135.414e-18
c867 n117__clk_b vss 145.663e-18
c868 n104__clk vss 191.816e-18
c869 n105__clk vss 100.92e-18
c870 n6__q6 vss 205.054e-18
c871 n160__rst vss 132.933e-18
c872 n96__rst_b vss 127.736e-18
c873 n10__i20__net1 vss 200.596e-18
c874 n153__rst vss 156.114e-18
c875 n151__rst vss 151.056e-18
c876 n4__q6 vss 127.493e-18
c877 n113__clk_b vss 80.5709e-18
c878 n101__clk vss 260.604e-18
c879 n109__clk_b vss 81.6687e-18
c880 n4__i20__net1 vss 90.7827e-18
c881 n14__q8 vss 180.642e-18
c882 n7__q7 vss 110.364e-18
c883 n147__rst vss 135.414e-18
c884 n106__clk_b vss 145.663e-18
c885 n94__clk vss 191.816e-18
c886 n95__clk vss 100.948e-18
c887 n6__q7 vss 204.065e-18
c888 n144__rst vss 132.933e-18
c889 n86__rst_b vss 127.736e-18
c890 n10__i30__net1 vss 200.596e-18
c891 n137__rst vss 156.114e-18
c892 n135__rst vss 151.056e-18
c893 n4__q7 vss 127.493e-18
c894 n102__clk_b vss 80.5709e-18
c895 n91__clk vss 260.604e-18
c896 n98__clk_b vss 81.6687e-18
c897 n4__i30__net1 vss 90.7827e-18
c898 n14__q9 vss 180.608e-18
c899 n7__q8 vss 110.364e-18
c900 n131__rst vss 135.414e-18
c901 n95__clk_b vss 145.663e-18
c902 n84__clk vss 191.816e-18
c903 n85__clk vss 100.948e-18
c904 n6__q8 vss 205.054e-18
c905 n128__rst vss 132.933e-18
c906 n76__rst_b vss 127.736e-18
c907 n10__i23__net1 vss 200.596e-18
c908 n121__rst vss 156.114e-18
c909 n119__rst vss 151.056e-18
c910 n4__q8 vss 127.493e-18
c911 n91__clk_b vss 80.5709e-18
c912 n81__clk vss 260.604e-18
c913 n87__clk_b vss 81.6687e-18
c914 n4__i23__net1 vss 90.7827e-18
c915 n14__q10 vss 180.566e-18
c916 n7__q9 vss 110.364e-18
c917 n115__rst vss 135.414e-18
c918 n84__clk_b vss 145.663e-18
c919 n74__clk vss 191.816e-18
c920 n75__clk vss 100.948e-18
c921 n6__q9 vss 205.054e-18
c922 n112__rst vss 132.933e-18
c923 n66__rst_b vss 127.736e-18
c924 n10__i25__net1 vss 200.596e-18
c925 n105__rst vss 156.114e-18
c926 n103__rst vss 151.056e-18
c927 n4__q9 vss 127.493e-18
c928 n80__clk_b vss 80.5709e-18
c929 n71__clk vss 260.604e-18
c930 n76__clk_b vss 81.6687e-18
c931 n4__i25__net1 vss 131.382e-18
c932 n14__q11 vss 180.566e-18
c933 n7__q10 vss 110.364e-18
c934 n99__rst vss 135.414e-18
c935 n73__clk_b vss 145.663e-18
c936 n64__clk vss 191.816e-18
c937 n65__clk vss 100.948e-18
c938 n6__q10 vss 205.054e-18
c939 n96__rst vss 132.933e-18
c940 n56__rst_b vss 127.736e-18
c941 n10__i24__net1 vss 200.596e-18
c942 n89__rst vss 156.114e-18
c943 n87__rst vss 151.056e-18
c944 n4__q10 vss 127.493e-18
c945 n69__clk_b vss 80.5709e-18
c946 n61__clk vss 260.93e-18
c947 n65__clk_b vss 81.6687e-18
c948 n4__i24__net1 vss 90.4902e-18
c949 n26__q12 vss 177.963e-18
c950 n7__q11 vss 110.368e-18
c951 n83__rst vss 135.414e-18
c952 n62__clk_b vss 145.609e-18
c953 n54__clk vss 192.721e-18
c954 n55__clk vss 100.871e-18
c955 n6__q11 vss 205.054e-18
c956 n80__rst vss 132.933e-18
c957 n46__rst_b vss 127.736e-18
c958 n10__i29__net1 vss 200.596e-18
c959 n73__rst vss 156.114e-18
c960 n71__rst vss 151.056e-18
c961 n4__q11 vss 127.493e-18
c962 n58__clk_b vss 81.7647e-18
c963 n51__clk vss 261.398e-18
c964 n54__clk_b vss 81.6687e-18
c965 n4__i29__net1 vss 91.2643e-18
c966 n14__q13 vss 180.519e-18
c967 n19__q12 vss 110.363e-18
c968 n67__rst vss 135.414e-18
c969 n51__clk_b vss 145.609e-18
c970 n44__clk vss 192.274e-18
c971 n45__clk vss 100.871e-18
c972 n18__q12 vss 205.054e-18
c973 n64__rst vss 132.933e-18
c974 n36__rst_b vss 127.736e-18
c975 n10__i26__net1 vss 200.596e-18
c976 n57__rst vss 156.121e-18
c977 n55__rst vss 151.088e-18
c978 n16__q12 vss 127.487e-18
c979 n47__clk_b vss 81.735e-18
c980 n41__clk vss 263.453e-18
c981 n43__clk_b vss 81.6687e-18
c982 n4__i26__net1 vss 90.6784e-18
c983 n25__q14 vss 180.732e-18
c984 n7__q13 vss 110.356e-18
c985 n51__rst vss 134.603e-18
c986 n40__clk_b vss 144.581e-18
c987 n34__clk vss 195.118e-18
c988 n35__clk vss 102.663e-18
c989 n6__q13 vss 204.92e-18
c990 n48__rst vss 132.958e-18
c991 n26__rst_b vss 127.775e-18
c992 n10__i28__net1 vss 200.67e-18
c993 n41__rst vss 156.077e-18
c994 n39__rst vss 151.058e-18
c995 n4__q13 vss 127.614e-18
c996 n36__clk_b vss 84.4298e-18
c997 n31__clk vss 264.325e-18
c998 n32__clk_b vss 81.0038e-18
c999 n4__i28__net1 vss 93.1219e-18
c1000 n13__q15 vss 187.344e-18
c1001 n20__q14 vss 109.479e-18
c1002 n35__rst vss 133.445e-18
c1003 n29__clk_b vss 141.717e-18
c1004 n24__clk vss 194.467e-18
c1005 n25__clk vss 128.584e-18
c1006 n19__q14 vss 205.328e-18
c1007 n32__rst vss 131.095e-18
c1008 n16__rst_b vss 130.032e-18
c1009 n10__i27__net1 vss 204.015e-18
c1010 n25__rst vss 162.587e-18
c1011 n23__rst vss 148.467e-18
c1012 n17__q14 vss 128.029e-18
c1013 n25__clk_b vss 84.3134e-18
c1014 n21__clk vss 257.923e-18
c1015 n21__clk_b vss 79.9868e-18
c1016 n4__i27__net1 vss 66.6689e-18
c1017 n15__xor1 vss 66.5195e-18
c1018 n14__i56__net1 vss 83.7545e-18
c1019 n15__xor2 vss 78.5491e-18
c1020 n3__d0 vss 1.26341e-15
c1021 n10__i56__net1 vss 72.6679e-18
c1022 n14__xor2 vss 161.179e-18
c1023 n6__i56__net2 vss 98.0033e-18
c1024 n8__i56__net1 vss 76.1938e-18
c1025 n2__i56__net2 vss 84.0491e-18
c1026 n10__xor2 vss 301.193e-18
c1027 n12__q14 vss 69.188e-18
c1028 n11__xor1 vss 108.899e-18
c1029 n6__i57__net2 vss 35.0617e-18
c1030 n10__q12 vss 110.041e-18
c1031 n15__i57__net1 vss 80.1821e-18
c1032 n6__i58__net2 vss 35.777e-18
c1033 n2__i57__net2 vss 99.956e-18
c1034 n11__q15 vss 290.778e-18
c1035 n12__i57__net1 vss 97.1498e-18
c1036 n15__i58__net1 vss 75.4072e-18
c1037 n10__q15 vss 178.036e-18
c1038 n7__i57__net1 vss 71.4159e-18
c1039 n6__q14 vss 88.2352e-18
c1040 n2__i58__net2 vss 100.272e-18
c1041 n14__q3 vss 106.572e-18
c1042 n13__i58__net1 vss 62.6079e-18
c1043 n5__xor1 vss 31.6381e-18
c1044 n10__q3 vss 153.171e-18
c1045 n6__q12 vss 154.748e-18
c1046 n57__vdd vss 8.22612e-15
c1047 n9__q0 vss 74.43e-18
c1048 n245__rst vss 272.369e-21
c1049 n56__vdd vss 51.9257e-18
c1050 n10__i0__net1 vss 89.7878e-21
c1051 n6__d0 vss 126.152e-21
c1052 n7__i0__x vss 106.374e-18
c1053 n11__q0 vss 60.6375e-18
c1054 n11__d0 vss 4.50419e-21
c1055 n8__i0__net1 vss 75.6313e-18
c1056 n6__i0__x vss 74.9279e-18
c1057 n58__vdd vss 58.0354e-18
c1058 n9__q1 vss 85.0335e-18
c1059 n236__rst vss 1.68052e-21
c1060 n59__vdd vss 52.0003e-18
c1061 n10__i16__net1 vss 89.7878e-21
c1062 n2__q0 vss 126.152e-21
c1063 n7__i16__x vss 106.793e-18
c1064 n11__q1 vss 69.2075e-18
c1065 n8__i16__net1 vss 75.4864e-18
c1066 n6__i16__x vss 76.5185e-18
c1067 n60__vdd vss 58.0354e-18
c1068 n9__q2 vss 85.0335e-18
c1069 n227__rst vss 1.68052e-21
c1070 n61__vdd vss 52.0003e-18
c1071 n10__i18__net1 vss 89.7878e-21
c1072 n2__q1 vss 126.152e-21
c1073 n7__i18__x vss 106.783e-18
c1074 n11__q2 vss 69.2075e-18
c1075 n8__i18__net1 vss 75.4864e-18
c1076 n6__i18__x vss 76.5185e-18
c1077 n62__vdd vss 58.0354e-18
c1078 n25__q3 vss 84.7804e-18
c1079 n218__rst vss 1.68052e-21
c1080 n63__vdd vss 53.0873e-18
c1081 n10__i17__net1 vss 89.7878e-21
c1082 n2__q2 vss 126.152e-21
c1083 n7__i17__x vss 108.32e-18
c1084 n27__q3 vss 68.8759e-18
c1085 n8__i17__net1 vss 75.4864e-18
c1086 n6__i17__x vss 76.5185e-18
c1087 n64__vdd vss 58.4317e-18
c1088 n14__q4 vss 85.2672e-18
c1089 n209__rst vss 1.68052e-21
c1090 n65__vdd vss 53.0917e-18
c1091 n11__i22__net1 vss 89.7878e-21
c1092 n16__q3 vss 126.152e-21
c1093 n7__i22__x vss 108.314e-18
c1094 n16__q4 vss 68.8759e-18
c1095 n9__i22__net1 vss 75.4864e-18
c1096 n6__i22__x vss 76.5185e-18
c1097 n66__vdd vss 57.9881e-18
c1098 n13__q5 vss 85.2672e-18
c1099 n193__rst vss 1.68052e-21
c1100 n67__vdd vss 53.0917e-18
c1101 n11__i19__net1 vss 89.7878e-21
c1102 n2__q4 vss 126.152e-21
c1103 n7__i19__x vss 108.314e-18
c1104 n15__q5 vss 68.8759e-18
c1105 n9__i19__net1 vss 75.4864e-18
c1106 n6__i19__x vss 76.5185e-18
c1107 n68__vdd vss 57.9881e-18
c1108 n13__q6 vss 85.2672e-18
c1109 n177__rst vss 1.68052e-21
c1110 n69__vdd vss 53.0917e-18
c1111 n11__i21__net1 vss 89.7878e-21
c1112 n2__q5 vss 126.152e-21
c1113 n7__i21__x vss 108.314e-18
c1114 n15__q6 vss 68.8759e-18
c1115 n9__i21__net1 vss 75.4864e-18
c1116 n6__i21__x vss 76.5185e-18
c1117 n70__vdd vss 57.9881e-18
c1118 n13__q7 vss 85.2672e-18
c1119 n161__rst vss 1.68052e-21
c1120 n71__vdd vss 53.0917e-18
c1121 n11__i20__net1 vss 89.7878e-21
c1122 n2__q6 vss 126.152e-21
c1123 n7__i20__x vss 108.314e-18
c1124 n15__q7 vss 68.8759e-18
c1125 n9__i20__net1 vss 75.4864e-18
c1126 n6__i20__x vss 76.5185e-18
c1127 n72__vdd vss 57.9881e-18
c1128 n13__q8 vss 85.2672e-18
c1129 n145__rst vss 1.68052e-21
c1130 n73__vdd vss 53.0917e-18
c1131 n11__i30__net1 vss 89.7878e-21
c1132 n2__q7 vss 126.152e-21
c1133 n7__i30__x vss 108.314e-18
c1134 n15__q8 vss 68.8759e-18
c1135 n9__i30__net1 vss 75.4864e-18
c1136 n6__i30__x vss 76.5185e-18
c1137 n74__vdd vss 57.9881e-18
c1138 n13__q9 vss 85.2672e-18
c1139 n129__rst vss 1.68052e-21
c1140 n75__vdd vss 53.0917e-18
c1141 n11__i23__net1 vss 89.7878e-21
c1142 n2__q8 vss 126.152e-21
c1143 n7__i23__x vss 108.314e-18
c1144 n15__q9 vss 68.8759e-18
c1145 n9__i23__net1 vss 75.4864e-18
c1146 n6__i23__x vss 76.5185e-18
c1147 n76__vdd vss 57.9881e-18
c1148 n13__q10 vss 85.2672e-18
c1149 n113__rst vss 1.68052e-21
c1150 n77__vdd vss 53.0917e-18
c1151 n11__i25__net1 vss 89.7878e-21
c1152 n2__q9 vss 126.152e-21
c1153 n7__i25__x vss 108.314e-18
c1154 n15__q10 vss 68.8759e-18
c1155 n9__i25__net1 vss 75.4864e-18
c1156 n6__i25__x vss 76.5185e-18
c1157 n78__vdd vss 57.9881e-18
c1158 n13__q11 vss 85.2672e-18
c1159 n97__rst vss 1.68052e-21
c1160 n79__vdd vss 53.0917e-18
c1161 n11__i24__net1 vss 89.7878e-21
c1162 n2__q10 vss 126.152e-21
c1163 n7__i24__x vss 108.314e-18
c1164 n15__q11 vss 68.8759e-18
c1165 n9__i24__net1 vss 75.4864e-18
c1166 n6__i24__x vss 76.7297e-18
c1167 n80__vdd vss 57.9881e-18
c1168 n25__q12 vss 85.1768e-18
c1169 n81__rst vss 1.68052e-21
c1170 n81__vdd vss 52.3143e-18
c1171 n11__i29__net1 vss 89.7878e-21
c1172 n2__q11 vss 126.152e-21
c1173 n7__i29__x vss 107.394e-18
c1174 n27__q12 vss 68.5485e-18
c1175 n9__i29__net1 vss 75.4864e-18
c1176 n6__i29__x vss 75.2759e-18
c1177 n82__vdd vss 57.9881e-18
c1178 n13__q13 vss 85.1768e-18
c1179 n65__rst vss 1.68052e-21
c1180 n83__vdd vss 52.3098e-18
c1181 n11__i26__net1 vss 89.7878e-21
c1182 n14__q12 vss 126.152e-21
c1183 n7__i26__x vss 107.411e-18
c1184 n15__q13 vss 68.6772e-18
c1185 n9__i26__net1 vss 75.4813e-18
c1186 n6__i26__x vss 75.5614e-18
c1187 n84__vdd vss 57.9881e-18
c1188 n24__q14 vss 85.1454e-18
c1189 n49__rst vss 1.68052e-21
c1190 n85__vdd vss 52.0769e-18
c1191 n11__i28__net1 vss 89.7878e-21
c1192 n2__q13 vss 49.4027e-21
c1193 n7__i28__x vss 108.461e-18
c1194 n26__q14 vss 68.5084e-18
c1195 n9__i28__net1 vss 75.4815e-18
c1196 n6__i28__x vss 74.8472e-18
c1197 n86__vdd vss 58.4966e-18
c1198 n12__q15 vss 81.2044e-18
c1199 n33__rst vss 3.36104e-21
c1200 n87__vdd vss 51.2061e-18
c1201 n11__i27__net1 vss 90.0897e-21
c1202 n15__q14 vss 98.3103e-21
c1203 n7__i27__x vss 106.703e-18
c1204 n14__q15 vss 77.5346e-18
c1205 n9__i27__net1 vss 75.4203e-18
c1206 n6__i27__x vss 76.8696e-18
c1207 n88__vdd vss 35.6431e-18
c1208 n14__xor1 vss 70.8886e-18
c1209 n16__xor1 vss 92.3098e-18
c1210 n5__i56__net2 vss 54.815e-18
c1211 n7__i56__net1 vss 41.8664e-18
c1212 n4__d0 vss 71.7913e-18
c1213 n7__i56__net2 vss 53.387e-18
c1214 n9__i56__net1 vss 46.6154e-18
c1215 n90__vdd vss 45.9211e-18
c1216 n3__i56__net2 vss 54.6282e-18
c1217 n7__i57__net2 vss 37.8965e-18
c1218 n94__vdd vss 44.291e-18
c1219 n91__vdd vss 43.5846e-18
c1220 n5__i57__net2 vss 55.3415e-18
c1221 n95__vdd vss 88.6777e-18
c1222 n16__i57__net1 vss 42.2139e-18
c1223 n5__i58__net2 vss 36.9933e-18
c1224 n3__i57__net2 vss 55.1041e-18
c1225 n13__xor2 vss 69.056e-18
c1226 n14__i58__net1 vss 41.4443e-18
c1227 n6__xor1 vss 110.453e-18
c1228 n92__vdd vss 43.452e-18
c1229 n14__i57__net1 vss 46.3659e-18
c1230 n7__i58__net2 vss 52.2663e-18
c1231 n55__vdd vss 95.2516e-18
c1232 n11__xor2 vss 262.354e-18
c1233 n16__i58__net1 vss 49.287e-18
c1234 n5__q14 vss 64.7961e-18
c1235 n3__i58__net2 vss 53.6357e-18
c1236 n8__xor1 vss 70.4636e-18
c1237 n5__q12 vss 67.7011e-18
c1238 n2__i58__net1 vss 21.3631e-18
c1239 n4__q3 vss 24.6479e-18
c1240 n2__i57__net1 vss 20.3595e-18
c1241 n4__q15 vss 23.7789e-18
c1242 n2__q12 vss 9.5068e-18
c1243 n2__xor1 vss 9.43847e-18
c1244 n2__q14 vss 10.1049e-18
c1245 n5__xor2 vss 24.8997e-18
c1246 n4__i56__net1 vss 21.044e-18
c1247 n2__rst vss 17.4236e-18
c1248 n2__i27__x vss 27.2202e-18
c1249 n9__i58__net1 vss 32.1538e-18
c1250 n7__rst vss 18.3299e-18
c1251 n2__i28__x vss 26.911e-18
c1252 n8__i57__net1 vss 32.134e-18
c1253 n12__rst vss 18.3299e-18
c1254 n2__i26__x vss 27.2475e-18
c1255 n17__rst vss 18.3299e-18
c1256 n2__i29__x vss 27.2306e-18
c1257 n16__xor2 vss 163.762e-18
c1258 n6__i27__net1 vss 36.8853e-18
c1259 n14__q14 vss 36.8137e-18
c1260 n18__q14 vss 42.2563e-18
c1261 n27__rst vss 18.3299e-18
c1262 n5__i27__x vss 43.489e-18
c1263 n18__rst_b vss 22.372e-18
c1264 n2__i24__x vss 27.2306e-18
c1265 n15__q15 vss 264.593e-18
c1266 n6__i28__net1 vss 40.3118e-18
c1267 n1__q13 vss 36.8829e-18
c1268 n5__q13 vss 41.8606e-18
c1269 n43__rst vss 18.3299e-18
c1270 n5__i28__x vss 43.5271e-18
c1271 n28__rst_b vss 22.4552e-18
c1272 n2__i25__x vss 27.2306e-18
c1273 n6__i26__net1 vss 40.5988e-18
c1274 n13__q12 vss 36.9592e-18
c1275 n17__q12 vss 41.8606e-18
c1276 n59__rst vss 18.3299e-18
c1277 n5__i26__x vss 43.4726e-18
c1278 n38__rst_b vss 22.0253e-18
c1279 n2__i23__x vss 27.2306e-18
c1280 n6__i29__net1 vss 40.5988e-18
c1281 n1__q11 vss 36.9592e-18
c1282 n5__q11 vss 41.8606e-18
c1283 n75__rst vss 18.3299e-18
c1284 n5__i29__x vss 43.4842e-18
c1285 n48__rst_b vss 22.0253e-18
c1286 n2__i30__x vss 27.2306e-18
c1287 n6__i24__net1 vss 40.5988e-18
c1288 n1__q10 vss 36.9592e-18
c1289 n5__q10 vss 41.8606e-18
c1290 n91__rst vss 18.3299e-18
c1291 n5__i24__x vss 43.5657e-18
c1292 n58__rst_b vss 22.0253e-18
c1293 n2__i20__x vss 27.2306e-18
c1294 n1__q9 vss 36.9592e-18
c1295 n5__q9 vss 41.8606e-18
c1296 n107__rst vss 18.3299e-18
c1297 n5__i25__x vss 43.5657e-18
c1298 n68__rst_b vss 22.0253e-18
c1299 n2__i21__x vss 27.2306e-18
c1300 n6__i23__net1 vss 40.5988e-18
c1301 n1__q8 vss 36.9592e-18
c1302 n5__q8 vss 41.8606e-18
c1303 n123__rst vss 18.3299e-18
c1304 n5__i23__x vss 43.5657e-18
c1305 n78__rst_b vss 22.0253e-18
c1306 n2__i19__x vss 27.2306e-18
c1307 n6__i30__net1 vss 40.5988e-18
c1308 n1__q7 vss 36.9592e-18
c1309 n5__q7 vss 41.8606e-18
c1310 n139__rst vss 18.3299e-18
c1311 n5__i30__x vss 43.5657e-18
c1312 n88__rst_b vss 22.0253e-18
c1313 n2__i22__x vss 27.2306e-18
c1314 n6__i20__net1 vss 40.5988e-18
c1315 n1__q6 vss 36.9592e-18
c1316 n5__q6 vss 41.8606e-18
c1317 n155__rst vss 18.3299e-18
c1318 n5__i20__x vss 43.5657e-18
c1319 n98__rst_b vss 22.0253e-18
c1320 n2__i17__x vss 27.2306e-18
c1321 n6__i21__net1 vss 40.5988e-18
c1322 n123__clk_b vss 21.4377e-18
c1323 n1__q5 vss 36.9592e-18
c1324 n5__q5 vss 41.8606e-18
c1325 n171__rst vss 18.3299e-18
c1326 n5__i21__x vss 43.5657e-18
c1327 n108__rst_b vss 22.0253e-18
c1328 n2__i18__x vss 27.2728e-18
c1329 n6__i19__net1 vss 40.5988e-18
c1330 n1__q4 vss 36.9592e-18
c1331 n5__q4 vss 41.8606e-18
c1332 n187__rst vss 18.3299e-18
c1333 n5__i19__x vss 43.5657e-18
c1334 n118__rst_b vss 22.0253e-18
c1335 n2__i16__x vss 27.2728e-18
c1336 n6__i22__net1 vss 40.5988e-18
c1337 n15__q3 vss 36.9592e-18
c1338 n19__q3 vss 41.8606e-18
c1339 n203__rst vss 18.4101e-18
c1340 n5__i22__x vss 43.5657e-18
c1341 n128__rst_b vss 22.0253e-18
c1342 n2__i0__x vss 28.2854e-18
c1343 n4__i17__net1 vss 40.5988e-18
c1344 n1__q2 vss 36.9592e-18
c1345 n5__q2 vss 41.8606e-18
c1346 n5__i17__x vss 43.5657e-18
c1347 n4__i18__net1 vss 40.6557e-18
c1348 n1__q1 vss 36.8579e-18
c1349 n5__q1 vss 41.8606e-18
c1350 n5__i18__x vss 44.1125e-18
c1351 n4__i16__net1 vss 40.6557e-18
c1352 n1__q0 vss 36.8579e-18
c1353 n5__q0 vss 41.8606e-18
c1354 n5__i16__x vss 44.1125e-18
c1355 n4__i0__net1 vss 40.6557e-18
c1356 n5__d0 vss 36.8603e-18
c1357 n9__d0 vss 41.8606e-18
c1358 n5__i0__x vss 43.5122e-18
c1359 n2__vdd vss 171.83e-18
c1360 n3__vdd vss 61.5716e-18
c1361 n4__vdd vss 48.8447e-18
c1362 n5__vdd vss 125.691e-18
c1363 n6__vdd vss 60.769e-18
c1364 n7__vdd vss 48.8388e-18
c1365 n8__vdd vss 125.691e-18
c1366 n9__vdd vss 60.7339e-18
c1367 n10__vdd vss 48.6292e-18
c1368 n11__vdd vss 125.685e-18
c1369 n12__vdd vss 60.4031e-18
c1370 n13__vdd vss 48.5163e-18
c1371 n14__vdd vss 125.691e-18
c1372 n15__vdd vss 60.4507e-18
c1373 n16__vdd vss 48.7259e-18
c1374 n17__vdd vss 125.691e-18
c1375 n18__vdd vss 60.4507e-18
c1376 n19__vdd vss 48.7259e-18
c1377 n20__vdd vss 125.691e-18
c1378 n21__vdd vss 60.4507e-18
c1379 n22__vdd vss 48.7259e-18
c1380 n23__vdd vss 125.691e-18
c1381 n24__vdd vss 60.4507e-18
c1382 n25__vdd vss 48.7259e-18
c1383 n26__vdd vss 125.691e-18
c1384 n27__vdd vss 60.4507e-18
c1385 n28__vdd vss 48.7259e-18
c1386 n29__vdd vss 125.691e-18
c1387 n30__vdd vss 60.4507e-18
c1388 n31__vdd vss 48.7259e-18
c1389 n32__vdd vss 125.691e-18
c1390 n33__vdd vss 60.455e-18
c1391 n34__vdd vss 48.7259e-18
c1392 n35__vdd vss 125.691e-18
c1393 n36__vdd vss 60.4507e-18
c1394 n37__vdd vss 48.7264e-18
c1395 n38__vdd vss 125.691e-18
c1396 n39__vdd vss 60.4507e-18
c1397 n40__vdd vss 48.7264e-18
c1398 n41__vdd vss 125.685e-18
c1399 n42__vdd vss 60.451e-18
c1400 n43__vdd vss 48.6696e-18
c1401 n44__vdd vss 125.877e-18
c1402 n45__vdd vss 60.7452e-18
c1403 n46__vdd vss 50.2632e-18
c1404 n47__vdd vss 127.048e-18
c1405 n48__vdd vss 59.6593e-18
c1406 n49__vdd vss 106.683e-18
c1407 n50__vdd vss 86.1433e-18
c1408 n51__vdd vss 28.8066e-18
c1409 n52__vdd vss 72.6005e-18
c1410 n53__vdd vss 28.9551e-18
c1411 n54__vdd vss 83.5994e-18
c1412 n89__vdd vss 7.0536e-18
c1413 n93__vdd vss 79.2339e-18
c1414 n142__rst_b vss 22.0253e-18
c1415 n145__rst_b vss 22.0253e-18
c1416 n148__rst_b vss 22.0253e-18
c1417 n151__rst_b vss 17.9636e-18
c1418 n13__q0 vss 12.8638e-18
c1419 n162__clk vss 234.549e-18
c1420 n163__clk vss 129.976e-18
c1421 n164__clk vss 124.255e-18
c1422 n165__clk vss 125.823e-18
c1423 n166__clk vss 128.216e-18
c1424 n167__clk vss 129.585e-18
c1425 n168__clk vss 129.585e-18
c1426 n169__clk vss 129.585e-18
c1427 n170__clk vss 131.318e-18
c1428 n171__clk vss 127.866e-18
c1429 n172__clk vss 129.585e-18
c1430 n173__clk vss 129.585e-18
c1431 n174__clk vss 128.895e-18
c1432 n175__clk vss 125.77e-18
c1433 n176__clk vss 132.758e-18
c1434 n17__q0 vss 104.422e-18
rg1 n31__q3 n13__q3 10.2819
rg2 n160__rst_b n159__rst_b 628.6e-3
rg3 n159__rst_b n158__rst_b 628.6e-3
rg4 n158__rst_b n157__rst_b 628.6e-3
rg5 n157__rst_b n123__rst_b 628.6e-3
rg6 n123__rst_b n113__rst_b 628.6e-3
rg7 n113__rst_b n103__rst_b 628.6e-3
rg8 n103__rst_b n93__rst_b 628.6e-3
rg9 n93__rst_b n83__rst_b 628.6e-3
rg10 n83__rst_b n73__rst_b 628.6e-3
rg11 n73__rst_b n63__rst_b 628.6e-3
rg12 n63__rst_b n53__rst_b 628.6e-3
rg13 n53__rst_b n43__rst_b 628.6e-3
rg14 n43__rst_b n33__rst_b 628.6e-3
rg15 n33__rst_b n23__rst_b 628.6e-3
rg16 n23__rst_b n13__rst_b 633.5e-3
rg17 n13__rst_b rst_b 15.96e-3
rh1 n12__q3 n13__q3 500e-3
rh2 n9__q14 n10__q14 1.2139
rh3 n18__xor1 n13__xor1 713.9e-3
rh4 n13__xor1 n10__xor1 1.0885
rh5 n13__rst_b n14__rst_b 1.0886
rh6 n23__rst_b n24__rst_b 1.0886
rh7 n29__q14 n23__q14 1.7247
rh8 n33__rst_b n34__rst_b 1.0886
rh9 n10__q13 n12__q13 1.2247
rh10 n43__rst_b n44__rst_b 1.0886
rh11 n22__q12 n24__q12 1.2067
rh12 n24__q12 n12__q12 4.1356
rh13 n12__q12 n9__q12 713.9e-3
rh14 n53__rst_b n54__rst_b 1.0886
rh15 n10__q11 n12__q11 1.2067
rh16 n63__rst_b n64__rst_b 1.0886
rh17 n10__q10 n12__q10 1.2067
rh18 n73__rst_b n74__rst_b 1.0886
rh19 n10__q9 n12__q9 1.2067
rh20 n83__rst_b n84__rst_b 1.0886
rh21 n10__q8 n12__q8 1.2067
rh22 n93__rst_b n94__rst_b 1.0886
rh23 n10__q7 n12__q7 1.2067
rh24 n103__rst_b n104__rst_b 1.0886
rh25 n10__q6 n12__q6 1.2067
rh26 n113__rst_b n114__rst_b 1.0886
rh27 n10__q5 n12__q5 1.2067
rh28 n123__rst_b n124__rst_b 1.0886
rh29 n10__q4 n12__q4 1.2067
rh30 n157__rst_b n153__rst_b 588.6e-3
rh31 n23__q3 n31__q3 1.0393
rh32 n31__q3 n30__q3 109.1e-3
rh33 n158__rst_b n154__rst_b 588.6e-3
rh34 n15__q2 n16__q2 1.2067
rh35 n159__rst_b n155__rst_b 588.6e-3
rh36 n15__q1 n16__q1 1.2067
rh37 n178__clk_b n177__clk_b 622.6e-3
rh38 n177__clk_b n176__clk_b 622.6e-3
rh39 n176__clk_b n175__clk_b 622.6e-3
rh40 n175__clk_b n147__clk_b 622.6e-3
rh41 n147__clk_b n136__clk_b 622.6e-3
rh42 n136__clk_b n125__clk_b 622.6e-3
rh43 n125__clk_b n112__clk_b 622.6e-3
rh44 n112__clk_b n101__clk_b 622.6e-3
rh45 n101__clk_b n90__clk_b 622.6e-3
rh46 n90__clk_b n79__clk_b 622.6e-3
rh47 n79__clk_b n68__clk_b 622.6e-3
rh48 n68__clk_b n57__clk_b 622.6e-3
rh49 n57__clk_b n46__clk_b 622.6e-3
rh50 n46__clk_b n35__clk_b 622.6e-3
rh51 n35__clk_b n24__clk_b 622.6e-3
rh52 n24__clk_b clk_b 170.2e-3
rh53 n160__rst_b n156__rst_b 588.6e-3
rh54 n16__q0 n17__q0 1.7724
ri1 n9__q12 n8__q12 500e-3
ri2 n10__q3 n12__q3 1
ri3 n11__i58__net1 n7__i58__net1 1.0905
ri4 n10__xor1 n9__xor1 500e-3
ri5 n8__q14 n9__q14 500e-3
ri6 n13__i57__net1 n10__i57__net1 1.0905
ri7 n8__i58__net2 n4__i58__net2 397.5e-3
ri8 n11__q12 n12__q12 500e-3
ri9 n8__i57__net2 n4__i57__net2 397.5e-3
ri10 n12__xor1 n13__xor1 500e-3
ri11 n8__i56__net2 n4__i56__net2 397.8e-3
ri12 n17__xor1 n18__xor1 500e-3
ri13 n16__i56__net1 n12__i56__net1 1.5902
ri14 n23__clk_b n24__clk_b 500e-3
ri15 n12__i27__net1 n5__i27__net1 761.8e-3
ri16 n31__rst n24__rst 902e-3
ri17 n19__rst_b n14__rst_b 4.873e-3
ri18 n22__q14 n23__q14 500e-3
ri19 n34__clk_b n35__clk_b 500e-3
ri20 n12__i28__net1 n5__i28__net1 761.8e-3
ri21 n47__rst n40__rst 902e-3
ri22 n29__rst_b n24__rst_b 4.873e-3
ri23 n28__q14 n29__q14 157e-3
ri24 n29__q14 n13__q14 1.452
ri25 n13__q14 n10__q14 602.5e-3
ri27 n9__q13 n10__q13 500e-3
ri28 n45__clk_b n46__clk_b 500e-3
ri29 n12__i26__net1 n5__i26__net1 776e-3
ri30 n63__rst n56__rst 902e-3
ri31 n39__rst_b n34__rst_b 4.873e-3
ri32 n11__q13 n12__q13 1.157
ri33 n21__q12 n22__q12 500e-3
ri34 n56__clk_b n57__clk_b 500e-3
ri35 n12__i29__net1 n5__i29__net1 776e-3
ri36 n79__rst n72__rst 902e-3
ri37 n49__rst_b n44__rst_b 4.873e-3
ri38 n23__q12 n24__q12 1.157
ri39 n9__q11 n10__q11 500e-3
ri40 n67__clk_b n68__clk_b 500e-3
ri41 n12__i24__net1 n5__i24__net1 776e-3
ri42 n95__rst n88__rst 902e-3
ri43 n59__rst_b n54__rst_b 4.873e-3
ri44 n11__q11 n12__q11 1.157
ri45 n9__q10 n10__q10 500e-3
ri46 n78__clk_b n79__clk_b 500e-3
ri47 n12__i25__net1 n5__i25__net1 776e-3
ri48 n111__rst n104__rst 902e-3
ri49 n69__rst_b n64__rst_b 4.873e-3
ri50 n11__q10 n12__q10 1.157
ri51 n9__q9 n10__q9 500e-3
ri52 n89__clk_b n90__clk_b 500e-3
ri53 n12__i23__net1 n5__i23__net1 776e-3
ri54 n127__rst n120__rst 902e-3
ri55 n79__rst_b n74__rst_b 4.873e-3
ri56 n11__q9 n12__q9 1.157
ri57 n9__q8 n10__q8 500e-3
ri58 n100__clk_b n101__clk_b 500e-3
ri59 n12__i30__net1 n5__i30__net1 776e-3
ri60 n143__rst n136__rst 902e-3
ri61 n89__rst_b n84__rst_b 4.873e-3
ri62 n11__q8 n12__q8 1.157
ri63 n9__q7 n10__q7 500e-3
ri64 n111__clk_b n112__clk_b 500e-3
ri65 n12__i20__net1 n5__i20__net1 776e-3
ri66 n159__rst n152__rst 902e-3
ri67 n99__rst_b n94__rst_b 4.873e-3
ri68 n11__q7 n12__q7 1.157
ri69 n9__q6 n10__q6 500e-3
ri70 n124__clk_b n125__clk_b 500e-3
ri71 n12__i21__net1 n5__i21__net1 776e-3
ri72 n175__rst n168__rst 902e-3
ri73 n109__rst_b n104__rst_b 4.873e-3
ri74 n11__q6 n12__q6 1.157
ri75 n9__q5 n10__q5 500e-3
ri76 n135__clk_b n136__clk_b 500e-3
ri77 n12__i19__net1 n5__i19__net1 776e-3
ri78 n191__rst n184__rst 902e-3
ri79 n119__rst_b n114__rst_b 4.873e-3
ri80 n11__q5 n12__q5 1.157
ri81 n9__q4 n10__q4 500e-3
ri82 n146__clk_b n147__clk_b 500e-3
ri83 n12__i22__net1 n5__i22__net1 776e-3
ri84 n207__rst n200__rst 902e-3
ri85 n129__rst_b n124__rst_b 4.873e-3
ri86 n11__q4 n12__q4 1.157
ri87 n21__q3 n23__q3 500e-3
ri88 n171__clk_b n175__clk_b 500e-3
ri89 n12__i17__net1 n11__i17__net1 776e-3
ri90 n250__rst n249__rst 402e-3
ri91 n143__rst_b n153__rst_b 504.9e-3
ri92 n29__q3 n30__q3 657e-3
ri93 n12__q2 n15__q2 500e-3
ri94 n172__clk_b n176__clk_b 500e-3
ri95 n12__i18__net1 n11__i18__net1 776e-3
ri96 n252__rst n251__rst 402e-3
ri97 n146__rst_b n154__rst_b 504.9e-3
ri98 n14__q2 n16__q2 657e-3
ri99 n12__q1 n15__q1 500e-3
ri100 n173__clk_b n177__clk_b 500e-3
ri101 n12__i16__net1 n11__i16__net1 776e-3
ri102 n254__rst n253__rst 402e-3
ri103 n149__rst_b n155__rst_b 504.9e-3
ri104 n14__q1 n16__q1 657e-3
ri105 n12__q0 n16__q0 500e-3
ri106 n174__clk_b n178__clk_b 500e-3
ri107 n12__i0__net1 n11__i0__net1 776e-3
ri108 n256__rst n255__rst 402e-3
ri109 n152__rst_b n156__rst_b 504.9e-3
ri110 clk n162__clk 1.398
ri111 n162__clk n27__clk 60.7e-3
ri112 n162__clk n163__clk 650.6e-3
ri113 n163__clk n37__clk 60.7e-3
ri114 n163__clk n164__clk 650.6e-3
ri115 n164__clk n47__clk 60.7e-3
ri116 n164__clk n165__clk 650.6e-3
ri117 n165__clk n57__clk 60.7e-3
ri118 n165__clk n166__clk 650.6e-3
ri119 n166__clk n67__clk 60.7e-3
ri120 n166__clk n167__clk 650.6e-3
ri121 n167__clk n77__clk 60.7e-3
ri122 n167__clk n168__clk 650.6e-3
ri123 n168__clk n87__clk 60.7e-3
ri124 n168__clk n169__clk 650.6e-3
ri125 n169__clk n97__clk 60.7e-3
ri126 n169__clk n170__clk 650.6e-3
ri127 n170__clk n107__clk 60.7e-3
ri128 n170__clk n171__clk 650.6e-3
ri129 n171__clk n118__clk 560.7e-3
ri130 n171__clk n172__clk 650.6e-3
ri131 n172__clk n128__clk 60.7e-3
ri132 n172__clk n173__clk 650.6e-3
ri133 n173__clk n138__clk 60.7e-3
ri134 n173__clk n174__clk 650.6e-3
ri135 n174__clk n158__clk 60.7e-3
ri136 n174__clk n175__clk 650.6e-3
ri137 n175__clk n159__clk 60.7e-3
ri138 n175__clk n176__clk 650.6e-3
ri139 n176__clk n160__clk 60.7e-3
ri140 n176__clk n161__clk 714.5e-3
ri141 n15__q0 n17__q0 116e-3
ri144 n13__q0 n17__q0 500e-3
rj1 n6__q12 n8__q12 1
rj2 n7__i58__net1 n8__i58__net1 1
rj3 n9__xor1 n5__xor1 500e-3
rj4 n14__q3 n10__q3 1.0852
rj6 n2__i58__net2 n4__i58__net2 1
rj7 n8__q14 n6__q14 1
rj8 n7__i57__net1 n10__i57__net1 1
rj9 n15__i58__net1 n11__i58__net1 850.3e-3
rj10 n11__i58__net1 n13__i58__net1 500e-3
rj11 n2__i57__net2 n4__i57__net2 1
rj12 n8__i58__net2 n6__i58__net2 1
rj13 n15__i57__net1 n13__i57__net1 850.3e-3
rj14 n13__i57__net1 n12__i57__net1 500e-3
rj15 n10__q12 n11__q12 1
rj16 n8__i57__net2 n6__i57__net2 1
rj17 n11__xor1 n12__xor1 1
rj18 n10__q14 n12__q14 1
rj19 n2__i56__net2 n4__i56__net2 1
rj20 n6__i56__net2 n8__i56__net2 1
rj21 n8__i56__net1 n12__i56__net1 850.3e-3
rj22 n12__i56__net1 n10__i56__net1 500e-3
rj23 n15__xor2 n16__xor2 58.33e-3
rj24 n16__xor2 n10__xor2 663.7e-3
rj25 n16__xor2 n14__xor2 1.0235
rj26 n17__xor1 n15__xor1 1
rj27 n14__i56__net1 n16__i56__net1 500e-3
rj28 n4__i27__net1 n5__i27__net1 1
rj29 n23__clk_b n21__clk_b 1
rj30 n23__rst n24__rst 1
rj31 n10__i27__net1 n12__i27__net1 1
rj32 n19__q14 n17__q14 1.5749
rj33 n32__rst n31__rst 500e-3
rj35 n18__rst_b n19__rst_b 500e-3
rj36 n16__rst_b n18__rst_b 500e-3
rj37 n29__clk_b n25__clk_b 1.3479
rj38 n25__clk n27__clk 1
rj39 n24__clk n21__clk 1.7127
rj40 n35__rst n25__rst 1.3259
rj41 q15 n15__q15 30.04e-3
rj42 n15__q15 n16__q15 1.7714
rj43 n16__q15 n10__q15 1.0852
rj44 n15__q15 n13__q15 991.1e-3
rj45 n11__q15 n16__q15 500e-3
rj46 n20__q14 n22__q14 500e-3
rj47 n4__i28__net1 n5__i28__net1 1
rj48 n34__clk_b n32__clk_b 1
rj49 n39__rst n40__rst 1
rj50 n10__i28__net1 n12__i28__net1 1
rj51 n6__q13 n4__q13 1.5749
rj52 n48__rst n47__rst 500e-3
rj54 n28__rst_b n29__rst_b 500e-3
rj55 n26__rst_b n28__rst_b 500e-3
rj56 n40__clk_b n36__clk_b 1.3479
rj57 n35__clk n37__clk 1
rj58 n34__clk n31__clk 1.7127
rj59 n51__rst n41__rst 1.3259
rj60 q14 n27__q14 447.9e-3
rj61 n27__q14 n28__q14 627.7e-3
rj62 n25__q14 n27__q14 500e-3
rj63 n9__q13 n7__q13 500e-3
rj64 n4__i26__net1 n5__i26__net1 1
rj65 n45__clk_b n43__clk_b 1
rj66 n55__rst n56__rst 1
rj67 n10__i26__net1 n12__i26__net1 1
rj68 n18__q12 n16__q12 1.5749
rj69 n64__rst n63__rst 500e-3
rj71 n38__rst_b n39__rst_b 500e-3
rj72 n36__rst_b n38__rst_b 500e-3
rj73 n51__clk_b n47__clk_b 1.3479
rj74 n45__clk n47__clk 1
rj75 n44__clk n41__clk 1.7127
rj76 n67__rst n57__rst 1.3259
rj77 q13 n16__q13 447.9e-3
rj78 n16__q13 n11__q13 127.7e-3
rj79 n14__q13 n16__q13 500e-3
rj80 n21__q12 n19__q12 500e-3
rj81 n4__i29__net1 n5__i29__net1 1
rj82 n56__clk_b n54__clk_b 1
rj83 n71__rst n72__rst 1
rj84 n10__i29__net1 n12__i29__net1 1
rj85 n6__q11 n4__q11 1.5749
rj86 n80__rst n79__rst 500e-3
rj88 n48__rst_b n49__rst_b 500e-3
rj89 n46__rst_b n48__rst_b 500e-3
rj90 n62__clk_b n58__clk_b 1.3479
rj91 n55__clk n57__clk 1
rj92 n54__clk n51__clk 1.7127
rj93 n83__rst n73__rst 1.3259
rj94 q12 n28__q12 447.9e-3
rj95 n28__q12 n23__q12 127.7e-3
rj96 n26__q12 n28__q12 500e-3
rj97 n9__q11 n7__q11 500e-3
rj98 n4__i24__net1 n5__i24__net1 1
rj99 n67__clk_b n65__clk_b 1
rj100 n87__rst n88__rst 1
rj101 n10__i24__net1 n12__i24__net1 1
rj102 n6__q10 n4__q10 1.5749
rj103 n96__rst n95__rst 500e-3
rj105 n58__rst_b n59__rst_b 500e-3
rj106 n56__rst_b n58__rst_b 500e-3
rj107 n73__clk_b n69__clk_b 1.3479
rj108 n65__clk n67__clk 1
rj109 n64__clk n61__clk 1.7127
rj110 n99__rst n89__rst 1.3259
rj111 q11 n16__q11 447.9e-3
rj112 n16__q11 n11__q11 127.7e-3
rj113 n14__q11 n16__q11 500e-3
rj114 n9__q10 n7__q10 500e-3
rj115 n4__i25__net1 n5__i25__net1 1
rj116 n78__clk_b n76__clk_b 1
rj117 n103__rst n104__rst 1
rj118 n10__i25__net1 n12__i25__net1 1
rj119 n6__q9 n4__q9 1.5749
rj120 n112__rst n111__rst 500e-3
rj122 n68__rst_b n69__rst_b 500e-3
rj123 n66__rst_b n68__rst_b 500e-3
rj124 n84__clk_b n80__clk_b 1.3479
rj125 n75__clk n77__clk 1
rj126 n74__clk n71__clk 1.7127
rj127 n115__rst n105__rst 1.3259
rj128 q10 n16__q10 447.9e-3
rj129 n16__q10 n11__q10 127.7e-3
rj130 n14__q10 n16__q10 500e-3
rj131 n9__q9 n7__q9 500e-3
rj132 n4__i23__net1 n5__i23__net1 1
rj133 n89__clk_b n87__clk_b 1
rj134 n119__rst n120__rst 1
rj135 n10__i23__net1 n12__i23__net1 1
rj136 n6__q8 n4__q8 1.5749
rj137 n128__rst n127__rst 500e-3
rj139 n78__rst_b n79__rst_b 500e-3
rj140 n76__rst_b n78__rst_b 500e-3
rj141 n95__clk_b n91__clk_b 1.3479
rj142 n85__clk n87__clk 1
rj143 n84__clk n81__clk 1.7127
rj144 n131__rst n121__rst 1.3259
rj145 q9 n16__q9 449.1e-3
rj146 n16__q9 n11__q9 127.7e-3
rj147 n14__q9 n16__q9 500e-3
rj148 n9__q8 n7__q8 500e-3
rj149 n4__i30__net1 n5__i30__net1 1
rj150 n100__clk_b n98__clk_b 1
rj151 n135__rst n136__rst 1
rj152 n10__i30__net1 n12__i30__net1 1
rj153 n6__q7 n4__q7 1.5749
rj154 n144__rst n143__rst 500e-3
rj156 n88__rst_b n89__rst_b 500e-3
rj157 n86__rst_b n88__rst_b 500e-3
rj158 n106__clk_b n102__clk_b 1.3479
rj159 n95__clk n97__clk 1
rj160 n94__clk n91__clk 1.7127
rj161 n147__rst n137__rst 1.3259
rj162 q8 n16__q8 449.1e-3
rj163 n16__q8 n11__q8 127.7e-3
rj164 n14__q8 n16__q8 500e-3
rj165 n9__q7 n7__q7 500e-3
rj166 n4__i20__net1 n5__i20__net1 1
rj167 n111__clk_b n109__clk_b 1
rj168 n151__rst n152__rst 1
rj169 n10__i20__net1 n12__i20__net1 1
rj170 n6__q6 n4__q6 1.5749
rj171 n160__rst n159__rst 500e-3
rj173 n98__rst_b n99__rst_b 500e-3
rj174 n96__rst_b n98__rst_b 500e-3
rj175 n117__clk_b n113__clk_b 1.3479
rj176 n105__clk n107__clk 1
rj177 n104__clk n101__clk 1.7127
rj178 n163__rst n153__rst 1.3259
rj179 q7 n16__q7 449.1e-3
rj180 n16__q7 n11__q7 127.7e-3
rj181 n14__q7 n16__q7 500e-3
rj182 n9__q6 n7__q6 500e-3
rj183 n4__i21__net1 n5__i21__net1 1
rj185 n123__clk_b n124__clk_b 500e-3
rj186 n120__clk_b n123__clk_b 500e-3
rj187 n167__rst n168__rst 1
rj188 n10__i21__net1 n12__i21__net1 1
rj189 n6__q5 n4__q5 1.5749
rj190 n176__rst n175__rst 500e-3
rj192 n108__rst_b n109__rst_b 500e-3
rj193 n106__rst_b n108__rst_b 500e-3
rj195 n118__clk n115__clk 500e-3
rj196 n130__clk_b n126__clk_b 1.3479
rj197 n114__clk n111__clk 1.7127
rj198 n179__rst n169__rst 1.3259
rj199 q6 n16__q6 449.4e-3
rj200 n16__q6 n11__q6 127.7e-3
rj201 n14__q6 n16__q6 500e-3
rj202 n9__q5 n7__q5 500e-3
rj203 n4__i19__net1 n5__i19__net1 1
rj204 n135__clk_b n133__clk_b 1
rj205 n183__rst n184__rst 1
rj206 n10__i19__net1 n12__i19__net1 1
rj207 n6__q4 n4__q4 1.5749
rj208 n192__rst n191__rst 500e-3
rj210 n118__rst_b n119__rst_b 500e-3
rj211 n116__rst_b n118__rst_b 500e-3
rj212 n141__clk_b n137__clk_b 1.3479
rj213 n126__clk n128__clk 1
rj214 n125__clk n122__clk 1.7127
rj215 n195__rst n185__rst 1.3259
rj216 q5 n16__q5 447.9e-3
rj217 n16__q5 n11__q5 127.7e-3
rj218 n14__q5 n16__q5 500e-3
rj219 n9__q4 n7__q4 500e-3
rj220 n4__i22__net1 n5__i22__net1 1
rj221 n146__clk_b n144__clk_b 1
rj222 n199__rst n200__rst 1
rj223 n10__i22__net1 n12__i22__net1 1
rj224 n20__q3 n18__q3 1.5749
rj225 n208__rst n207__rst 500e-3
rj227 n128__rst_b n129__rst_b 500e-3
rj228 n126__rst_b n128__rst_b 500e-3
rj229 n152__clk_b n148__clk_b 1.3479
rj230 n136__clk n138__clk 1
rj231 n135__clk n132__clk 1.7127
rj232 n211__rst n201__rst 1.3259
rj233 q4 n13__q4 449.1e-3
rj234 n13__q4 n11__q4 127.7e-3
rj235 n21__q3 n22__q3 1
rj236 n5__i17__net1 n11__i17__net1 1
rj237 n171__clk_b n155__clk_b 1
rj238 n215__rst n249__rst 1
rj239 n9__i17__net1 n12__i17__net1 1
rj240 n7__q2 n4__q2 1.5749
rj241 n217__rst n250__rst 1
rj243 n142__rst_b n143__rst_b 500e-3
rj244 n134__rst_b n142__rst_b 500e-3
rj245 n158__clk_b n157__clk_b 1.3479
rj246 n144__clk n158__clk 1
rj247 n143__clk n142__clk 1.7127
rj248 n220__rst n216__rst 1.3259
rj249 q3 n28__q3 447.9e-3
rj250 n28__q3 n29__q3 627.7e-3
rj251 n26__q3 n28__q3 500e-3
rj252 n12__q2 n6__q2 500e-3
rj253 n5__i18__net1 n11__i18__net1 1
rj254 n172__clk_b n159__clk_b 1
rj255 n224__rst n251__rst 1
rj256 n9__i18__net1 n12__i18__net1 1
rj257 n7__q1 n4__q1 1.5749
rj258 n226__rst n252__rst 1
rj260 n145__rst_b n146__rst_b 500e-3
rj261 n136__rst_b n145__rst_b 500e-3
rj262 n162__clk_b n161__clk_b 1.3479
rj263 n148__clk n159__clk 1
rj264 n147__clk n146__clk 1.7127
rj265 n229__rst n225__rst 1.3259
rj266 q2 n13__q2 447.9e-3
rj267 n13__q2 n14__q2 627.7e-3
rj268 n10__q2 n13__q2 500e-3
rj269 n12__q1 n6__q1 500e-3
rj270 n5__i16__net1 n11__i16__net1 1
rj271 n173__clk_b n163__clk_b 1
rj272 n233__rst n253__rst 1
rj273 n9__i16__net1 n12__i16__net1 1
rj274 n7__q0 n4__q0 1.5749
rj275 n235__rst n254__rst 1
rj277 n148__rst_b n149__rst_b 500e-3
rj278 n138__rst_b n148__rst_b 500e-3
rj279 n166__clk_b n165__clk_b 1.3479
rj280 n152__clk n160__clk 1
rj281 n151__clk n150__clk 1.7127
rj282 n238__rst n234__rst 1.3259
rj283 q1 n13__q1 447.9e-3
rj284 n13__q1 n14__q1 627.7e-3
rj285 n10__q1 n13__q1 500e-3
rj286 n12__q0 n6__q0 500e-3
rj287 n5__i0__net1 n11__i0__net1 1
rj288 n174__clk_b n167__clk_b 1
rj289 n242__rst n255__rst 1
rj290 n9__i0__net1 n12__i0__net1 1
rj291 n8__d0 n13__d0 1.0751
rj292 n13__d0 n3__d0 10.4729
rj293 n10__d0 n13__d0 500e-3
rj294 n244__rst n256__rst 1
rj296 n151__rst_b n152__rst_b 500e-3
rj297 n140__rst_b n151__rst_b 500e-3
rj298 n170__clk_b n169__clk_b 1.3479
rj299 n156__clk n161__clk 1
rj300 n155__clk n154__clk 1.7127
rj301 n247__rst n243__rst 1.3251
rj302 q0 n13__q0 437.5e-3
rj304 n13__q0 n15__q0 623.2e-3
rj305 n10__q0 n13__q0 500e-3
rk1 n5__q12 n6__q12 31.3009
rk2 n6__q12 n7__q12 75.0035
rk3 n10__q3 n2__q3 502.3e-3
rk4 n8__i58__net1 n9__i58__net1 1.296e-3
rk5 n3__i58__net1 n10__i58__net1 1.296e-3
rk6 n9__i58__net1 n10__i58__net1 17.36e-3
rk7 n5__xor1 n7__xor1 865.4e-3
rk8 n7__xor1 n8__xor1 31.3665
rk9 n6__xor1 n7__xor1 75
rk10 i58__net2 n2__i58__net2 75.2429
rk11 n2__i58__net2 n3__i58__net2 31.0799
rk13 n13__i58__net1 n5__i58__net1 2.818e-3
rk14 n14__i58__net1 n15__i58__net1 75.1339
rk15 n15__i58__net1 n16__i58__net1 31.1785
rk16 n5__q14 n6__q14 31.3009
rk17 n6__q14 n7__q14 75.0035
rk18 n2__q15 n10__q15 3.634e-3
rk19 n7__i57__net1 n8__i57__net1 1.296e-3
rk20 n3__i57__net1 n9__i57__net1 1.296e-3
rk21 n8__i57__net1 n9__i57__net1 17.36e-3
rk22 n8__q3 n14__q3 196.4e-3
rk23 n14__q3 n3__q3 3.332e-3
rk24 i57__net2 n2__i57__net2 31.0799
rk25 n2__i57__net2 n3__i57__net2 75.2429
rk26 n5__i58__net2 n6__i58__net2 75.1339
rk27 n6__i58__net2 n7__i58__net2 31.1717
rk29 n12__i57__net1 n5__i57__net1 3.1e-3
rk30 n14__i57__net1 n15__i57__net1 31.1785
rk31 n15__i57__net1 n16__i57__net1 75.1339
rk32 n9__q15 n11__q15 196.4e-3
rk33 n11__q15 n3__q15 3.332e-3
rk34 n1__q12 n10__q12 2.894e-3
rk35 n5__i57__net2 n6__i57__net2 31.1717
rk36 n6__i57__net2 n7__i57__net2 75.1339
rk37 n11__xor1 n3__xor1 2.894e-3
rk38 n10__xor2 n12__xor2 1.847
rk39 n12__xor2 n13__xor2 75.3665
rk40 n11__xor2 n12__xor2 31
rk41 n1__q14 n12__q14 2.894e-3
rk42 i56__net2 n2__i56__net2 75.1339
rk43 n2__i56__net2 n3__i56__net2 31.1717
rk44 n7__i56__net1 n8__i56__net1 75.1339
rk45 n8__i56__net1 n9__i56__net1 31.1785
rk46 n5__i56__net2 n6__i56__net2 75.2429
rk47 n6__i56__net2 n7__i56__net2 31.0799
rk48 xor2 n14__xor2 196.4e-3
rk49 n14__xor2 n6__xor2 3.332e-3
rk50 n2__i56__net1 n10__i56__net1 2.818e-3
rk52 n2__d0 n3__d0 798.9e-3
rk53 n2__d0 n4__d0 31.3665
rk54 d0 n2__d0 75
rk55 n8__xor2 n15__xor2 502.3e-3
rk56 n14__xor1 n15__xor1 31.3028
rk57 n15__xor1 n16__xor1 75.0035
rk58 n3__i56__net1 n13__i56__net1 1.296e-3
rk59 n14__i56__net1 n15__i56__net1 1.296e-3
rk60 n13__i56__net1 n15__i56__net1 17.36e-3
rk61 n6__i27__net1 n4__i27__net1 6.44e-3
rk62 n7__i27__net1 n8__i27__net1 6.413e-3
rk63 n6__i27__net1 n8__i27__net1 26.61e-3
rk64 n2__i27__net1 n7__i27__net1 45
rk65 n3__clk_b n21__clk_b 2.715e-3
rk67 n25__clk_b n1__clk_b 19.86e-3
rk68 n21__clk n2__clk 2.537e-3
rk69 n14__q14 n16__q14 2.643e-3
rk70 n17__q14 n18__q14 2.643e-3
rk71 n14__q14 n18__q14 15.61e-3
rk72 n15__q14 n16__q14 31
rk73 n22__rst n23__rst 7.006e-3
rk74 n21__rst n22__rst 75
rk75 n3__rst n25__rst 3.332e-3
rk76 n9__i27__net1 n10__i27__net1 75.3757
rk77 n10__i27__net1 n11__i27__net1 31.003
rk78 n3__i27__x n5__i27__x 81.45e-3
rk79 n5__i27__x n6__i27__x 75.2512
rk80 n5__i27__x n7__i27__x 31.367
rk82 n16__rst_b n3__rst_b 3.332e-3
rk83 n3__clk n24__clk 4.839e-3
rk84 n5__clk n25__clk 2.715e-3
rk86 n29__clk_b n5__clk_b 3.332e-3
rk87 n32__rst n34__rst 13.74e-3
rk88 n34__rst n35__rst 358.4e-3
rk90 n33__rst n34__rst 31
rk91 n12__q15 n13__q15 31.1844
rk92 n13__q15 n14__q15 75.3663
rk93 n20__q14 n19__q14 675.9e-3
rk94 n19__q14 n21__q14 75.003
rk95 n6__i28__net1 n4__i28__net1 6.44e-3
rk96 n7__i28__net1 n8__i28__net1 6.413e-3
rk97 n6__i28__net1 n8__i28__net1 26.61e-3
rk98 n2__i28__net1 n7__i28__net1 45
rk99 n8__clk_b n32__clk_b 2.715e-3
rk101 n36__clk_b n6__clk_b 19.86e-3
rk102 n31__clk n7__clk 2.537e-3
rk103 n1__q13 n3__q13 2.643e-3
rk104 n4__q13 n5__q13 2.643e-3
rk105 n1__q13 n5__q13 15.61e-3
rk106 n2__q13 n3__q13 31
rk107 n38__rst n39__rst 7.006e-3
rk108 n37__rst n38__rst 75
rk109 n8__rst n41__rst 3.332e-3
rk110 n9__i28__net1 n10__i28__net1 75.3757
rk111 n10__i28__net1 n11__i28__net1 31.003
rk112 n3__i28__x n5__i28__x 81.45e-3
rk113 n5__i28__x n6__i28__x 75.2512
rk114 n5__i28__x n7__i28__x 31.367
rk116 n26__rst_b n6__rst_b 9.995e-3
rk117 n8__clk n34__clk 4.839e-3
rk118 n10__clk n35__clk 2.715e-3
rk120 n40__clk_b n10__clk_b 3.332e-3
rk121 n48__rst n50__rst 13.74e-3
rk122 n50__rst n51__rst 358.4e-3
rk124 n49__rst n50__rst 31
rk125 n24__q14 n25__q14 31.3037
rk126 n25__q14 n26__q14 75.2613
rk127 n7__q13 n6__q13 675.9e-3
rk128 n6__q13 n8__q13 75.003
rk129 n6__i26__net1 n4__i26__net1 6.44e-3
rk130 n7__i26__net1 n8__i26__net1 6.413e-3
rk131 n6__i26__net1 n8__i26__net1 26.61e-3
rk132 n2__i26__net1 n7__i26__net1 45
rk133 n13__clk_b n43__clk_b 2.715e-3
rk135 n47__clk_b n11__clk_b 19.86e-3
rk136 n41__clk n12__clk 2.537e-3
rk137 n13__q12 n15__q12 2.643e-3
rk138 n16__q12 n17__q12 2.643e-3
rk139 n13__q12 n17__q12 15.61e-3
rk140 n14__q12 n15__q12 31
rk141 n54__rst n55__rst 7.006e-3
rk142 n53__rst n54__rst 75
rk143 n13__rst n57__rst 3.332e-3
rk144 n9__i26__net1 n10__i26__net1 75.3757
rk145 n10__i26__net1 n11__i26__net1 31.003
rk146 n3__i26__x n5__i26__x 81.45e-3
rk147 n5__i26__x n6__i26__x 75.2512
rk148 n5__i26__x n7__i26__x 31.367
rk150 n36__rst_b n9__rst_b 9.995e-3
rk151 n13__clk n44__clk 4.839e-3
rk152 n15__clk n45__clk 2.715e-3
rk154 n51__clk_b n15__clk_b 3.332e-3
rk155 n64__rst n66__rst 13.74e-3
rk156 n66__rst n67__rst 358.4e-3
rk158 n65__rst n66__rst 31
rk159 n13__q13 n14__q13 31.3037
rk160 n14__q13 n15__q13 75.2613
rk161 n19__q12 n18__q12 675.9e-3
rk162 n18__q12 n20__q12 75.003
rk163 n6__i29__net1 n4__i29__net1 6.44e-3
rk164 n7__i29__net1 n8__i29__net1 6.413e-3
rk165 n6__i29__net1 n8__i29__net1 26.61e-3
rk166 n2__i29__net1 n7__i29__net1 45
rk167 n18__clk_b n54__clk_b 2.715e-3
rk169 n58__clk_b n16__clk_b 19.86e-3
rk170 n51__clk n17__clk 2.537e-3
rk171 n1__q11 n3__q11 2.643e-3
rk172 n4__q11 n5__q11 2.643e-3
rk173 n1__q11 n5__q11 15.61e-3
rk174 n2__q11 n3__q11 31
rk175 n70__rst n71__rst 7.006e-3
rk176 n69__rst n70__rst 75
rk177 n18__rst n73__rst 3.332e-3
rk178 n9__i29__net1 n10__i29__net1 75.3757
rk179 n10__i29__net1 n11__i29__net1 31.003
rk180 n3__i29__x n5__i29__x 81.45e-3
rk181 n5__i29__x n6__i29__x 75.2512
rk182 n5__i29__x n7__i29__x 31.367
rk184 n46__rst_b n12__rst_b 9.995e-3
rk185 n18__clk n54__clk 4.839e-3
rk186 n20__clk n55__clk 2.715e-3
rk188 n62__clk_b n20__clk_b 3.332e-3
rk189 n80__rst n82__rst 13.74e-3
rk190 n82__rst n83__rst 358.4e-3
rk192 n81__rst n82__rst 31
rk193 n25__q12 n26__q12 31.3037
rk194 n26__q12 n27__q12 75.2613
rk195 n7__q11 n6__q11 675.9e-3
rk196 n6__q11 n8__q11 75.003
rk197 n6__i24__net1 n4__i24__net1 6.44e-3
rk198 n7__i24__net1 n8__i24__net1 6.413e-3
rk199 n6__i24__net1 n8__i24__net1 26.61e-3
rk200 n2__i24__net1 n7__i24__net1 45
rk201 n28__clk_b n65__clk_b 2.715e-3
rk203 n69__clk_b n26__clk_b 19.86e-3
rk204 n61__clk n23__clk 2.537e-3
rk205 n1__q10 n3__q10 2.643e-3
rk206 n4__q10 n5__q10 2.643e-3
rk207 n1__q10 n5__q10 15.61e-3
rk208 n2__q10 n3__q10 31
rk209 n86__rst n87__rst 7.006e-3
rk210 n85__rst n86__rst 75
rk211 n28__rst n89__rst 3.332e-3
rk212 n9__i24__net1 n10__i24__net1 75.3757
rk213 n10__i24__net1 n11__i24__net1 31.003
rk214 n3__i24__x n5__i24__x 81.45e-3
rk215 n5__i24__x n6__i24__x 75.2512
rk216 n5__i24__x n7__i24__x 31.367
rk218 n56__rst_b n22__rst_b 9.995e-3
rk219 n28__clk n64__clk 4.839e-3
rk220 n30__clk n65__clk 2.715e-3
rk222 n73__clk_b n31__clk_b 3.332e-3
rk223 n96__rst n98__rst 13.74e-3
rk224 n98__rst n99__rst 358.4e-3
rk226 n97__rst n98__rst 31
rk227 n13__q11 n14__q11 31.3037
rk228 n14__q11 n15__q11 75.2613
rk229 n7__q10 n6__q10 675.9e-3
rk230 n6__q10 n8__q10 75.003
rk231 n6__i25__net1 n4__i25__net1 6.44e-3
rk232 n7__i25__net1 n8__i25__net1 6.413e-3
rk233 n6__i25__net1 n8__i25__net1 26.61e-3
rk234 n2__i25__net1 n7__i25__net1 45
rk235 n39__clk_b n76__clk_b 2.715e-3
rk237 n80__clk_b n37__clk_b 19.86e-3
rk238 n71__clk n33__clk 2.537e-3
rk239 n1__q9 n3__q9 2.643e-3
rk240 n4__q9 n5__q9 2.643e-3
rk241 n1__q9 n5__q9 15.61e-3
rk242 n2__q9 n3__q9 31
rk243 n102__rst n103__rst 7.006e-3
rk244 n101__rst n102__rst 75
rk245 n44__rst n105__rst 3.332e-3
rk246 n9__i25__net1 n10__i25__net1 75.3757
rk247 n10__i25__net1 n11__i25__net1 31.003
rk248 n3__i25__x n5__i25__x 81.45e-3
rk249 n5__i25__x n6__i25__x 75.2512
rk250 n5__i25__x n7__i25__x 31.367
rk252 n66__rst_b n32__rst_b 9.995e-3
rk253 n38__clk n74__clk 4.839e-3
rk254 n40__clk n75__clk 2.715e-3
rk256 n84__clk_b n42__clk_b 3.332e-3
rk257 n112__rst n114__rst 13.74e-3
rk258 n114__rst n115__rst 358.4e-3
rk260 n113__rst n114__rst 31
rk261 n13__q10 n14__q10 31.3037
rk262 n14__q10 n15__q10 75.2613
rk263 n7__q9 n6__q9 675.9e-3
rk264 n6__q9 n8__q9 75.003
rk265 n6__i23__net1 n4__i23__net1 6.44e-3
rk266 n7__i23__net1 n8__i23__net1 6.413e-3
rk267 n6__i23__net1 n8__i23__net1 26.61e-3
rk268 n2__i23__net1 n7__i23__net1 45
rk269 n50__clk_b n87__clk_b 2.715e-3
rk271 n91__clk_b n48__clk_b 19.86e-3
rk272 n81__clk n43__clk 2.537e-3
rk273 n1__q8 n3__q8 2.643e-3
rk274 n4__q8 n5__q8 2.643e-3
rk275 n1__q8 n5__q8 15.61e-3
rk276 n2__q8 n3__q8 31
rk277 n118__rst n119__rst 7.006e-3
rk278 n117__rst n118__rst 75
rk279 n60__rst n121__rst 3.332e-3
rk280 n9__i23__net1 n10__i23__net1 75.3757
rk281 n10__i23__net1 n11__i23__net1 31.003
rk282 n3__i23__x n5__i23__x 81.45e-3
rk283 n5__i23__x n6__i23__x 75.2512
rk284 n5__i23__x n7__i23__x 31.367
rk286 n76__rst_b n42__rst_b 9.995e-3
rk287 n48__clk n84__clk 4.839e-3
rk288 n50__clk n85__clk 2.715e-3
rk290 n95__clk_b n53__clk_b 3.332e-3
rk291 n128__rst n130__rst 13.74e-3
rk292 n130__rst n131__rst 358.4e-3
rk294 n129__rst n130__rst 31
rk295 n13__q9 n14__q9 31.3037
rk296 n14__q9 n15__q9 75.2613
rk297 n7__q8 n6__q8 675.9e-3
rk298 n6__q8 n8__q8 75.003
rk299 n6__i30__net1 n4__i30__net1 6.44e-3
rk300 n7__i30__net1 n8__i30__net1 6.413e-3
rk301 n6__i30__net1 n8__i30__net1 26.61e-3
rk302 n2__i30__net1 n7__i30__net1 45
rk303 n61__clk_b n98__clk_b 2.715e-3
rk305 n102__clk_b n59__clk_b 19.86e-3
rk306 n91__clk n53__clk 2.537e-3
rk307 n1__q7 n3__q7 2.643e-3
rk308 n4__q7 n5__q7 2.643e-3
rk309 n1__q7 n5__q7 15.61e-3
rk310 n2__q7 n3__q7 31
rk311 n134__rst n135__rst 7.006e-3
rk312 n133__rst n134__rst 75
rk313 n76__rst n137__rst 3.332e-3
rk314 n9__i30__net1 n10__i30__net1 75.3757
rk315 n10__i30__net1 n11__i30__net1 31.003
rk316 n3__i30__x n5__i30__x 81.45e-3
rk317 n5__i30__x n6__i30__x 75.2512
rk318 n5__i30__x n7__i30__x 31.367
rk320 n86__rst_b n52__rst_b 9.995e-3
rk321 n58__clk n94__clk 4.839e-3
rk322 n60__clk n95__clk 2.715e-3
rk324 n106__clk_b n64__clk_b 3.332e-3
rk325 n144__rst n146__rst 13.74e-3
rk326 n146__rst n147__rst 358.4e-3
rk328 n145__rst n146__rst 31
rk329 n13__q8 n14__q8 31.3037
rk330 n14__q8 n15__q8 75.2613
rk331 n7__q7 n6__q7 675.9e-3
rk332 n6__q7 n8__q7 75.003
rk333 n6__i20__net1 n4__i20__net1 6.44e-3
rk334 n7__i20__net1 n8__i20__net1 6.413e-3
rk335 n6__i20__net1 n8__i20__net1 26.61e-3
rk336 n2__i20__net1 n7__i20__net1 45
rk337 n72__clk_b n109__clk_b 2.715e-3
rk339 n113__clk_b n70__clk_b 19.86e-3
rk340 n101__clk n63__clk 2.537e-3
rk341 n1__q6 n3__q6 2.643e-3
rk342 n4__q6 n5__q6 2.643e-3
rk343 n1__q6 n5__q6 15.61e-3
rk344 n2__q6 n3__q6 31
rk345 n150__rst n151__rst 7.006e-3
rk346 n149__rst n150__rst 75
rk347 n92__rst n153__rst 3.332e-3
rk348 n9__i20__net1 n10__i20__net1 75.3757
rk349 n10__i20__net1 n11__i20__net1 31.003
rk350 n3__i20__x n5__i20__x 81.45e-3
rk351 n5__i20__x n6__i20__x 75.2512
rk352 n5__i20__x n7__i20__x 31.367
rk354 n96__rst_b n62__rst_b 9.995e-3
rk355 n68__clk n104__clk 4.839e-3
rk356 n70__clk n105__clk 2.715e-3
rk358 n117__clk_b n75__clk_b 3.332e-3
rk359 n160__rst n162__rst 13.74e-3
rk360 n162__rst n163__rst 358.4e-3
rk362 n161__rst n162__rst 31
rk363 n13__q7 n14__q7 31.3037
rk364 n14__q7 n15__q7 75.2613
rk365 n7__q6 n6__q6 675.9e-3
rk366 n6__q6 n8__q6 75.003
rk367 n6__i21__net1 n4__i21__net1 6.44e-3
rk368 n7__i21__net1 n8__i21__net1 6.413e-3
rk369 n6__i21__net1 n8__i21__net1 26.61e-3
rk370 n2__i21__net1 n7__i21__net1 45
rk371 n83__clk_b n120__clk_b 2.715e-3
rk373 n126__clk_b n81__clk_b 19.86e-3
rk374 n111__clk n73__clk 2.537e-3
rk375 n1__q5 n3__q5 2.643e-3
rk376 n4__q5 n5__q5 2.643e-3
rk377 n1__q5 n5__q5 15.61e-3
rk378 n2__q5 n3__q5 31
rk379 n166__rst n167__rst 7.006e-3
rk380 n165__rst n166__rst 75
rk381 n108__rst n169__rst 3.332e-3
rk382 n9__i21__net1 n10__i21__net1 75.3757
rk383 n10__i21__net1 n11__i21__net1 31.003
rk384 n3__i21__x n5__i21__x 81.45e-3
rk385 n5__i21__x n6__i21__x 75.2512
rk386 n5__i21__x n7__i21__x 31.367
rk388 n106__rst_b n72__rst_b 9.995e-3
rk389 n78__clk n114__clk 4.839e-3
rk390 n80__clk n115__clk 2.715e-3
rk392 n130__clk_b n86__clk_b 3.332e-3
rk393 n176__rst n178__rst 13.74e-3
rk394 n178__rst n179__rst 358.4e-3
rk396 n177__rst n178__rst 31
rk397 n13__q6 n14__q6 31.3037
rk398 n14__q6 n15__q6 75.2613
rk399 n7__q5 n6__q5 675.9e-3
rk400 n6__q5 n8__q5 75.003
rk401 n6__i19__net1 n4__i19__net1 6.44e-3
rk402 n7__i19__net1 n8__i19__net1 6.413e-3
rk403 n6__i19__net1 n8__i19__net1 26.61e-3
rk404 n2__i19__net1 n7__i19__net1 45
rk405 n94__clk_b n133__clk_b 2.715e-3
rk407 n137__clk_b n92__clk_b 19.86e-3
rk408 n122__clk n83__clk 2.537e-3
rk409 n1__q4 n3__q4 2.643e-3
rk410 n4__q4 n5__q4 2.643e-3
rk411 n1__q4 n5__q4 15.61e-3
rk412 n2__q4 n3__q4 31
rk413 n182__rst n183__rst 7.006e-3
rk414 n181__rst n182__rst 75
rk415 n124__rst n185__rst 3.332e-3
rk416 n9__i19__net1 n10__i19__net1 75.3757
rk417 n10__i19__net1 n11__i19__net1 31.003
rk418 n3__i19__x n5__i19__x 81.45e-3
rk419 n5__i19__x n6__i19__x 75.2512
rk420 n5__i19__x n7__i19__x 31.367
rk422 n116__rst_b n82__rst_b 9.995e-3
rk423 n88__clk n125__clk 4.839e-3
rk424 n90__clk n126__clk 2.715e-3
rk426 n141__clk_b n97__clk_b 3.332e-3
rk427 n192__rst n194__rst 13.74e-3
rk428 n194__rst n195__rst 358.4e-3
rk430 n193__rst n194__rst 31
rk431 n13__q5 n14__q5 31.3037
rk432 n14__q5 n15__q5 75.2613
rk433 n7__q4 n6__q4 675.9e-3
rk434 n6__q4 n8__q4 75.003
rk435 n6__i22__net1 n4__i22__net1 6.44e-3
rk436 n7__i22__net1 n8__i22__net1 6.413e-3
rk437 n6__i22__net1 n8__i22__net1 26.61e-3
rk438 n2__i22__net1 n7__i22__net1 45
rk439 n105__clk_b n144__clk_b 2.715e-3
rk441 n148__clk_b n103__clk_b 19.86e-3
rk442 n132__clk n93__clk 2.537e-3
rk443 n15__q3 n17__q3 2.643e-3
rk444 n18__q3 n19__q3 2.643e-3
rk445 n15__q3 n19__q3 15.61e-3
rk446 n16__q3 n17__q3 31
rk447 n198__rst n199__rst 7.006e-3
rk448 n197__rst n198__rst 75
rk449 n140__rst n201__rst 3.332e-3
rk450 n9__i22__net1 n10__i22__net1 75.3757
rk451 n10__i22__net1 n11__i22__net1 31.003
rk452 n3__i22__x n5__i22__x 81.45e-3
rk453 n5__i22__x n6__i22__x 75.2512
rk454 n5__i22__x n7__i22__x 31.367
rk456 n126__rst_b n92__rst_b 9.995e-3
rk457 n98__clk n135__clk 4.839e-3
rk458 n100__clk n136__clk 2.715e-3
rk460 n152__clk_b n108__clk_b 3.332e-3
rk461 n208__rst n210__rst 13.74e-3
rk462 n210__rst n211__rst 358.4e-3
rk464 n209__rst n210__rst 31
rk465 n14__q4 n15__q4 31.3037
rk466 n15__q4 n16__q4 75.2613
rk467 n13__q4 n15__q4 500e-3
rk468 n22__q3 n20__q3 175.9e-3
rk469 n20__q3 n24__q3 75.003
rk470 n4__i17__net1 n5__i17__net1 6.44e-3
rk471 n6__i17__net1 n7__i17__net1 6.413e-3
rk472 n4__i17__net1 n7__i17__net1 26.61e-3
rk473 n2__i17__net1 n6__i17__net1 45
rk474 n116__clk_b n155__clk_b 2.715e-3
rk476 n157__clk_b n114__clk_b 19.86e-3
rk477 n142__clk n103__clk 2.537e-3
rk478 n1__q2 n3__q2 2.643e-3
rk479 n4__q2 n5__q2 2.643e-3
rk480 n1__q2 n5__q2 15.61e-3
rk481 n2__q2 n3__q2 31
rk482 n214__rst n215__rst 7.006e-3
rk483 n213__rst n214__rst 75
rk484 n156__rst n216__rst 3.332e-3
rk485 n8__i17__net1 n9__i17__net1 75.3757
rk486 n9__i17__net1 n10__i17__net1 31.003
rk487 n3__i17__x n5__i17__x 81.45e-3
rk488 n5__i17__x n6__i17__x 75.2512
rk489 n5__i17__x n7__i17__x 31.367
rk491 n134__rst_b n102__rst_b 9.995e-3
rk492 n108__clk n143__clk 4.839e-3
rk493 n110__clk n144__clk 2.715e-3
rk495 n158__clk_b n119__clk_b 3.332e-3
rk496 n217__rst n219__rst 13.74e-3
rk497 n219__rst n220__rst 358.4e-3
rk499 n218__rst n219__rst 31
rk500 n25__q3 n26__q3 31.3037
rk501 n26__q3 n27__q3 75.2613
rk502 n6__q2 n7__q2 675.9e-3
rk503 n7__q2 n8__q2 75.003
rk504 n4__i18__net1 n5__i18__net1 6.44e-3
rk505 n6__i18__net1 n7__i18__net1 6.413e-3
rk506 n4__i18__net1 n7__i18__net1 26.61e-3
rk507 n2__i18__net1 n6__i18__net1 45
rk508 n129__clk_b n159__clk_b 2.715e-3
rk510 n161__clk_b n127__clk_b 19.86e-3
rk511 n146__clk n113__clk 2.537e-3
rk512 n1__q1 n3__q1 2.643e-3
rk513 n4__q1 n5__q1 2.643e-3
rk514 n1__q1 n5__q1 15.61e-3
rk515 n2__q1 n3__q1 31
rk516 n223__rst n224__rst 7.006e-3
rk517 n222__rst n223__rst 75
rk518 n172__rst n225__rst 3.332e-3
rk519 n8__i18__net1 n9__i18__net1 75.3757
rk520 n9__i18__net1 n10__i18__net1 31.003
rk521 n3__i18__x n5__i18__x 81.45e-3
rk522 n5__i18__x n6__i18__x 75.2512
rk523 n5__i18__x n7__i18__x 31.367
rk525 n136__rst_b n112__rst_b 9.995e-3
rk526 n119__clk n147__clk 4.839e-3
rk527 n121__clk n148__clk 2.715e-3
rk529 n162__clk_b n132__clk_b 3.332e-3
rk530 n226__rst n228__rst 13.74e-3
rk531 n228__rst n229__rst 358.4e-3
rk533 n227__rst n228__rst 31
rk534 n9__q2 n10__q2 31.3037
rk535 n10__q2 n11__q2 75.2613
rk536 n6__q1 n7__q1 675.9e-3
rk537 n7__q1 n8__q1 75.003
rk538 n4__i16__net1 n5__i16__net1 6.44e-3
rk539 n6__i16__net1 n7__i16__net1 6.413e-3
rk540 n4__i16__net1 n7__i16__net1 26.61e-3
rk541 n2__i16__net1 n6__i16__net1 45
rk542 n140__clk_b n163__clk_b 2.715e-3
rk544 n165__clk_b n138__clk_b 19.86e-3
rk545 n150__clk n124__clk 2.537e-3
rk546 n1__q0 n3__q0 2.643e-3
rk547 n4__q0 n5__q0 2.643e-3
rk548 n1__q0 n5__q0 15.61e-3
rk549 n2__q0 n3__q0 31
rk550 n232__rst n233__rst 7.006e-3
rk551 n231__rst n232__rst 75
rk552 n188__rst n234__rst 3.332e-3
rk553 n8__i16__net1 n9__i16__net1 75.3757
rk554 n9__i16__net1 n10__i16__net1 31.003
rk555 n3__i16__x n5__i16__x 81.45e-3
rk556 n5__i16__x n6__i16__x 75.2512
rk557 n5__i16__x n7__i16__x 31.367
rk559 n138__rst_b n122__rst_b 9.995e-3
rk560 n129__clk n151__clk 4.839e-3
rk561 n131__clk n152__clk 2.715e-3
rk563 n166__clk_b n143__clk_b 3.332e-3
rk564 n235__rst n237__rst 13.74e-3
rk565 n237__rst n238__rst 358.4e-3
rk567 n236__rst n237__rst 31
rk568 n9__q1 n10__q1 31.3037
rk569 n10__q1 n11__q1 75.2613
rk570 n6__q0 n7__q0 675.9e-3
rk571 n7__q0 n8__q0 75.003
rk572 n4__i0__net1 n5__i0__net1 6.44e-3
rk573 n6__i0__net1 n7__i0__net1 6.413e-3
rk574 n4__i0__net1 n7__i0__net1 26.61e-3
rk575 n2__i0__net1 n6__i0__net1 45
rk576 n151__clk_b n167__clk_b 2.715e-3
rk578 n169__clk_b n149__clk_b 19.86e-3
rk579 n154__clk n134__clk 2.537e-3
rk580 n5__d0 n7__d0 2.643e-3
rk581 n8__d0 n9__d0 2.643e-3
rk582 n5__d0 n9__d0 15.61e-3
rk583 n6__d0 n7__d0 31
rk584 n241__rst n242__rst 7.006e-3
rk585 n240__rst n241__rst 75
rk586 n204__rst n243__rst 3.332e-3
rk587 n206__rst n190__rst 1.0662
rk588 n190__rst n174__rst 1.0662
rk589 n174__rst n158__rst 1.0662
rk590 n158__rst n142__rst 1.0662
rk591 n142__rst n126__rst 1.0662
rk592 n126__rst n110__rst 1.0662
rk593 n110__rst n94__rst 1.0662
rk594 n94__rst n78__rst 1.0662
rk595 n78__rst n62__rst 1.0662
rk596 n62__rst n46__rst 1.0662
rk597 n46__rst n30__rst 1.0662
rk598 n30__rst n20__rst 1.0662
rk599 n20__rst n15__rst 1.0662
rk600 n15__rst n10__rst 1.0662
rk601 n10__rst rst 46.062
rk602 n8__i0__net1 n9__i0__net1 75.3757
rk603 n9__i0__net1 n10__i0__net1 31.003
rk604 n3__i0__x n5__i0__x 81.45e-3
rk605 n5__i0__x n6__i0__x 75.2512
rk606 n5__i0__x n7__i0__x 31.367
rk608 n140__rst_b n132__rst_b 9.995e-3
rk609 n139__clk n155__clk 4.839e-3
rk610 n141__clk n156__clk 2.715e-3
rk612 n170__clk_b n154__clk_b 3.332e-3
rk613 n10__d0 n12__d0 2.999e-3
rk614 n11__d0 n12__d0 75
rk615 n244__rst n246__rst 13.74e-3
rk616 n246__rst n247__rst 358.4e-3
rk618 n245__rst n246__rst 31
rk619 n9__q0 n10__q0 31.3016
rk620 n10__q0 n11__q0 75.2634
rk622 n2__vdd n3__vdd 343.9e-3
rk623 n3__vdd n4__vdd 141.5e-3
rk624 n4__vdd n5__vdd 524.3e-3
rk625 n5__vdd n6__vdd 343.9e-3
rk626 n6__vdd n7__vdd 141.5e-3
rk627 n7__vdd n8__vdd 524.3e-3
rk628 n8__vdd n9__vdd 343.9e-3
rk629 n9__vdd n10__vdd 141.5e-3
rk630 n10__vdd n11__vdd 524.3e-3
rk631 n11__vdd n12__vdd 343.9e-3
rk632 n12__vdd n13__vdd 141.5e-3
rk633 n13__vdd n14__vdd 524.3e-3
rk634 n14__vdd n15__vdd 343.9e-3
rk635 n15__vdd n16__vdd 141.5e-3
rk636 n16__vdd n17__vdd 524.3e-3
rk637 n17__vdd n18__vdd 343.9e-3
rk638 n18__vdd n19__vdd 141.5e-3
rk639 n19__vdd n20__vdd 524.3e-3
rk640 n20__vdd n21__vdd 343.9e-3
rk641 n21__vdd n22__vdd 141.5e-3
rk642 n22__vdd n23__vdd 524.3e-3
rk643 n23__vdd n24__vdd 343.9e-3
rk644 n24__vdd n25__vdd 141.5e-3
rk645 n25__vdd n26__vdd 524.3e-3
rk646 n26__vdd n27__vdd 343.9e-3
rk647 n27__vdd n28__vdd 141.5e-3
rk648 n28__vdd n29__vdd 524.3e-3
rk649 n29__vdd n30__vdd 343.9e-3
rk650 n30__vdd n31__vdd 141.5e-3
rk651 n31__vdd n32__vdd 524.3e-3
rk652 n32__vdd n33__vdd 343.9e-3
rk653 n33__vdd n34__vdd 141.5e-3
rk654 n34__vdd n35__vdd 524.3e-3
rk655 n35__vdd n36__vdd 343.9e-3
rk656 n36__vdd n37__vdd 141.5e-3
rk657 n37__vdd n38__vdd 524.3e-3
rk658 n38__vdd n39__vdd 343.9e-3
rk659 n39__vdd n40__vdd 141.5e-3
rk660 n40__vdd n41__vdd 524.3e-3
rk661 n41__vdd n42__vdd 343.9e-3
rk662 n42__vdd n43__vdd 141.5e-3
rk663 n43__vdd n44__vdd 524.3e-3
rk664 n44__vdd n45__vdd 343.9e-3
rk665 n45__vdd n46__vdd 141.5e-3
rk666 n46__vdd n47__vdd 523.8e-3
rk667 n47__vdd n48__vdd 343.9e-3
rk668 n48__vdd n49__vdd 141.5e-3
rk669 n49__vdd n50__vdd 1.226
rk670 n50__vdd n51__vdd 175.2e-3
rk671 n51__vdd n52__vdd 336.7e-3
rk672 n52__vdd n53__vdd 219.8e-3
rk673 n53__vdd vdd 45.34e-3
rk674 vdd n54__vdd 174.5e-3
rk675 n54__vdd n55__vdd 31.5425
rk676 n2__vdd n56__vdd 31.1444
rk677 n3__vdd n57__vdd 75.1177
rk678 n4__vdd n58__vdd 31.1369
rk679 n5__vdd n59__vdd 31.1444
rk680 n6__vdd n57__vdd 75.1177
rk681 n7__vdd n60__vdd 31.1369
rk682 n8__vdd n61__vdd 31.1444
rk683 n9__vdd n57__vdd 75.1177
rk684 n10__vdd n62__vdd 31.1369
rk685 n11__vdd n63__vdd 31.1444
rk686 n12__vdd n57__vdd 75.1177
rk687 n13__vdd n64__vdd 31.1369
rk688 n14__vdd n65__vdd 31.1444
rk689 n15__vdd n57__vdd 75.1177
rk690 n16__vdd n66__vdd 31.1369
rk691 n17__vdd n67__vdd 31.1444
rk692 n18__vdd n57__vdd 75.1177
rk693 n19__vdd n68__vdd 31.1369
rk694 n20__vdd n69__vdd 31.1444
rk695 n21__vdd n57__vdd 75.1177
rk696 n22__vdd n70__vdd 31.1369
rk697 n23__vdd n71__vdd 31.1444
rk698 n24__vdd n57__vdd 75.1177
rk699 n25__vdd n72__vdd 31.1369
rk700 n26__vdd n73__vdd 31.1444
rk701 n27__vdd n57__vdd 75.1177
rk702 n28__vdd n74__vdd 31.1369
rk703 n29__vdd n75__vdd 31.1444
rk704 n30__vdd n57__vdd 75.1177
rk705 n31__vdd n76__vdd 31.1369
rk706 n32__vdd n77__vdd 31.1444
rk707 n33__vdd n57__vdd 75.1177
rk708 n34__vdd n78__vdd 31.1369
rk709 n35__vdd n79__vdd 31.1444
rk710 n36__vdd n57__vdd 75.1177
rk711 n37__vdd n80__vdd 31.1369
rk712 n38__vdd n81__vdd 31.1444
rk713 n39__vdd n57__vdd 75.1177
rk714 n40__vdd n82__vdd 31.1369
rk715 n41__vdd n83__vdd 31.1444
rk716 n42__vdd n57__vdd 75.1177
rk717 n43__vdd n84__vdd 31.1369
rk718 n44__vdd n85__vdd 31.1444
rk719 n45__vdd n57__vdd 75.1177
rk720 n46__vdd n86__vdd 31.1369
rk721 n47__vdd n87__vdd 31.1444
rk722 n48__vdd n57__vdd 75.1177
rk723 n49__vdd n88__vdd 31.1687
rk724 n50__vdd n89__vdd 91.52e-3
rk725 n89__vdd n57__vdd 75.1444
rk726 n51__vdd n90__vdd 31.1596
rk727 n52__vdd n91__vdd 31.1333
rk728 n53__vdd n57__vdd 75.1444
rk729 n54__vdd n92__vdd 31.1333
rk730 n89__vdd n93__vdd 195.2e-3
rk731 n93__vdd n94__vdd 31.1333
rk732 n93__vdd n95__vdd 31.5027
rk733 n1__vss n2__vss 75.0944
rk734 n2__vss n3__vss 2.8874
rk735 n3__vss n4__vss 1.1768
rk736 n4__vss n5__vss 1.1768
rk737 n5__vss n6__vss 1.1768
rk738 n6__vss n7__vss 1.1768
rk739 n7__vss n8__vss 1.1768
rk740 n8__vss n9__vss 1.1768
rk741 n9__vss n10__vss 1.1768
rk742 n10__vss n11__vss 1.1768
rk743 n11__vss n12__vss 1.1768
rk744 n12__vss n13__vss 1.1768
rk745 n13__vss n14__vss 1.1768
rk746 n14__vss n15__vss 1.1768
rk747 n15__vss n16__vss 1.1768
rk748 n16__vss n17__vss 1.1768
rk749 n17__vss n18__vss 1.129
rk750 n18__vss n19__vss 1.2265
rk751 n19__vss n20__vss 308.4e-3
rk752 n20__vss n21__vss 188.1e-3
rk753 n21__vss vss 42.43e-3
rk754 vss n22__vss 145.7e-3
rk755 n22__vss n23__vss 75.4266
rk756 n2__vss n24__vss 562.9e-3
rk757 n24__vss n25__vss 565.7e-3
rk758 n25__vss n26__vss 562.9e-3
rk759 n26__vss n27__vss 565.7e-3
rk760 n27__vss n28__vss 562.9e-3
rk761 n28__vss n29__vss 565.7e-3
rk762 n29__vss n30__vss 562.9e-3
rk763 n30__vss n31__vss 565.7e-3
rk764 n31__vss n32__vss 562.9e-3
rk765 n32__vss n33__vss 565.7e-3
rk766 n33__vss n34__vss 562.9e-3
rk767 n34__vss n35__vss 565.7e-3
rk768 n35__vss n36__vss 562.9e-3
rk769 n36__vss n37__vss 565.7e-3
rk770 n37__vss n38__vss 562.9e-3
rk771 n38__vss n39__vss 565.7e-3
rk772 n39__vss n40__vss 562.9e-3
rk773 n40__vss n41__vss 565.7e-3
rk774 n41__vss n42__vss 562.9e-3
rk775 n42__vss n43__vss 565.7e-3
rk776 n43__vss n44__vss 562.9e-3
rk777 n44__vss n45__vss 565.7e-3
rk778 n45__vss n46__vss 562.9e-3
rk779 n46__vss n47__vss 565.7e-3
rk780 n47__vss n48__vss 562.9e-3
rk781 n48__vss n49__vss 565.7e-3
rk782 n49__vss n50__vss 562.9e-3
rk783 n50__vss n51__vss 565.7e-3
rk784 n51__vss n52__vss 562.9e-3
rk785 n52__vss n53__vss 565.7e-3
rk786 n53__vss n54__vss 562.9e-3
rk787 n54__vss n55__vss 175.2e-3
rk788 n55__vss n56__vss 901.5e-3
rk789 n56__vss n57__vss 188.1e-3
rk790 n57__vss n58__vss 75.4266
rk791 n3__vss n59__vss 62.0758
rk792 n4__vss n59__vss 62.0758
rk793 n5__vss n59__vss 62.0758
rk794 n6__vss n59__vss 62.0758
rk795 n7__vss n59__vss 62.0758
rk796 n8__vss n59__vss 62.0758
rk797 n9__vss n59__vss 62.0758
rk798 n10__vss n59__vss 62.0758
rk799 n11__vss n59__vss 62.0758
rk800 n12__vss n59__vss 62.0758
rk801 n13__vss n59__vss 62.0758
rk802 n14__vss n59__vss 62.0758
rk803 n15__vss n59__vss 62.0758
rk804 n16__vss n59__vss 62.0758
rk805 n17__vss n59__vss 62.0758
rk806 n18__vss n59__vss 62.0758
rk807 n19__vss n60__vss 75.1152
rk808 n20__vss n61__vss 75.0889
rk809 n21__vss n59__vss 62.0844
rk810 n22__vss n62__vss 75.0889
rk811 n24__vss n63__vss 75.0967
rk812 n25__vss n64__vss 75.0944
rk813 n26__vss n65__vss 75.0967
rk814 n27__vss n66__vss 75.0944
rk815 n28__vss n67__vss 75.0967
rk816 n29__vss n68__vss 75.0944
rk817 n30__vss n69__vss 75.0967
rk818 n31__vss n70__vss 75.0944
rk819 n32__vss n71__vss 75.0967
rk820 n33__vss n72__vss 75.0944
rk821 n34__vss n73__vss 75.0967
rk822 n35__vss n74__vss 75.0944
rk823 n36__vss n75__vss 75.0967
rk824 n37__vss n76__vss 75.0944
rk825 n38__vss n77__vss 75.0967
rk826 n39__vss n78__vss 75.0944
rk827 n40__vss n79__vss 75.0967
rk828 n41__vss n80__vss 75.0944
rk829 n42__vss n81__vss 75.0967
rk830 n43__vss n82__vss 75.0944
rk831 n44__vss n83__vss 75.0967
rk832 n45__vss n84__vss 75.0944
rk833 n46__vss n85__vss 75.0967
rk834 n47__vss n86__vss 75.0944
rk835 n48__vss n87__vss 75.0967
rk836 n49__vss n88__vss 75.0944
rk837 n50__vss n89__vss 75.0967
rk838 n51__vss n90__vss 75.0944
rk839 n52__vss n91__vss 75.0967
rk840 n53__vss n92__vss 75.0944
rk841 n54__vss n93__vss 75.0944
rk842 n55__vss n59__vss 62.1207
rk843 n56__vss n59__vss 62.0844
rk844 n57__vss n94__vss 75.0889
rl2 n2__i58__net1 n3__i58__net1 49.3144
rl3 n2__i58__net1 n4__i58__net1 34.3295
rl4 n1__q3 n2__q3 79.0806
rl5 n5__i58__net1 i58__net1 77.5981
rl6 n3__q3 n4__q3 50.1171
rl7 n4__q3 n5__q3 34.3295
rl9 n1__q15 n2__q15 79.0806
rl10 i57__net1 n2__i57__net1 34.3295
rl11 n2__i57__net1 n3__i57__net1 49.3144
rl13 n7__q3 n8__q3 81.9242
rl14 n7__q3 n9__q3 100
rl15 n5__i57__net1 n6__i57__net1 77.5981
rl16 n3__q15 n4__q15 50.1171
rl18 n4__q15 n6__q15 34.3295
rl19 n1__q12 n2__q12 50.1171
rl20 n2__q12 n3__q12 43.9449
rl21 n2__q12 n4__q12 47.791
rl22 n7__q15 n8__q15 100
rl23 n8__q15 n9__q15 81.9242
rl24 xor1 n2__xor1 47.791
rl25 n2__xor1 n3__xor1 50.1123
rl26 n2__xor1 n4__xor1 43.9449
rl27 n1__q14 n2__q14 50.1171
rl28 n2__q14 n3__q14 47.791
rl29 n2__q14 n4__q14 43.9449
rl30 xor2 n2__xor2 84.2177
rl31 n2__xor2 n3__xor2 100
rl33 n5__xor2 n6__xor2 50.1123
rl34 n5__xor2 n7__xor2 34.3295
rl35 i56__net1 n2__i56__net1 76.7349
rl36 n3__i56__net1 n4__i56__net1 49.3192
rl37 n4__i56__net1 n5__i56__net1 34.3295
rl39 n8__xor2 n9__xor2 79.9438
rl40 i27__net1 n2__i27__net1 72.3097
rl41 n2__i27__net1 n3__i27__net1 72.3097
rl42 n1__clk n2__clk 71.1559
rl43 n1__clk_b n2__clk_b 69.2328
rl44 n2__clk_b n3__clk_b 111.54
rl45 n1__rst n2__rst 38.1757
rl46 n2__rst n3__rst 49.3144
rl47 n2__rst n4__rst 80.4834
rl48 n4__rst rst 67.058
rl50 n1__rst_b n2__rst_b 126.923
rl51 n2__rst_b n3__rst_b 69.2328
rl52 i27__x n2__i27__x 99.7141
rl53 n2__i27__x n3__i27__x 50.1123
rl54 n2__i27__x n4__i27__x 65.0987
rl55 n4__clk_b n5__clk_b 71.1559
rl56 n3__clk n4__clk 69.2328
rl57 n4__clk n5__clk 111.54
rl58 i28__net1 n2__i28__net1 72.3097
rl59 n2__i28__net1 n3__i28__net1 72.3097
rl60 n6__clk n7__clk 71.1559
rl61 n6__clk_b n7__clk_b 69.2328
rl62 n7__clk_b n8__clk_b 111.54
rl63 n6__rst n7__rst 38.1757
rl64 n7__rst n8__rst 49.3144
rl65 n7__rst n9__rst 80.4834
rl66 n9__rst n10__rst 111.54
rl67 n4__rst_b n5__rst_b 126.923
rl68 n5__rst_b n6__rst_b 69.2328
rl69 i28__x n2__i28__x 99.7141
rl70 n2__i28__x n3__i28__x 50.1123
rl71 n2__i28__x n4__i28__x 65.0987
rl72 n9__clk_b n10__clk_b 71.1559
rl73 n8__clk n9__clk 69.2328
rl74 n9__clk n10__clk 111.54
rl75 i26__net1 n2__i26__net1 72.3097
rl76 n2__i26__net1 n3__i26__net1 72.3097
rl77 n11__clk n12__clk 71.1559
rl78 n11__clk_b n12__clk_b 69.2328
rl79 n12__clk_b n13__clk_b 111.54
rl80 n11__rst n12__rst 38.1757
rl81 n12__rst n13__rst 49.3144
rl82 n12__rst n14__rst 80.4834
rl83 n14__rst n15__rst 111.54
rl84 n7__rst_b n8__rst_b 126.923
rl85 n8__rst_b n9__rst_b 69.2328
rl86 i26__x n2__i26__x 99.7141
rl87 n2__i26__x n3__i26__x 50.1123
rl88 n2__i26__x n4__i26__x 65.0987
rl89 n14__clk_b n15__clk_b 71.1559
rl90 n13__clk n14__clk 69.2328
rl91 n14__clk n15__clk 111.54
rl92 i29__net1 n2__i29__net1 72.3097
rl93 n2__i29__net1 n3__i29__net1 72.3097
rl94 n16__clk n17__clk 71.1559
rl95 n16__clk_b n17__clk_b 69.2328
rl96 n17__clk_b n18__clk_b 111.54
rl97 n16__rst n17__rst 38.1757
rl98 n17__rst n18__rst 49.3144
rl99 n17__rst n19__rst 80.4834
rl100 n19__rst n20__rst 111.54
rl101 n10__rst_b n11__rst_b 126.923
rl102 n11__rst_b n12__rst_b 69.2328
rl103 i29__x n2__i29__x 99.7141
rl104 n2__i29__x n3__i29__x 50.1123
rl105 n2__i29__x n4__i29__x 65.0987
rl106 n19__clk_b n20__clk_b 71.1559
rl107 n18__clk n19__clk 69.2328
rl108 n19__clk n20__clk 111.54
rl109 i24__net1 n2__i24__net1 72.3097
rl110 n2__i24__net1 n3__i24__net1 72.3097
rl111 n22__clk n23__clk 71.1559
rl112 n26__clk_b n27__clk_b 69.2328
rl113 n27__clk_b n28__clk_b 111.54
rl114 n26__rst n27__rst 38.1757
rl115 n27__rst n28__rst 49.3144
rl116 n27__rst n29__rst 80.4834
rl117 n29__rst n30__rst 111.54
rl118 n20__rst_b n21__rst_b 126.923
rl119 n21__rst_b n22__rst_b 69.2328
rl120 i24__x n2__i24__x 99.7141
rl121 n2__i24__x n3__i24__x 50.1123
rl122 n2__i24__x n4__i24__x 65.0987
rl123 n30__clk_b n31__clk_b 71.1559
rl124 n28__clk n29__clk 69.2328
rl125 n29__clk n30__clk 111.54
rl126 i25__net1 n2__i25__net1 72.3097
rl127 n2__i25__net1 n3__i25__net1 72.3097
rl128 n32__clk n33__clk 71.1559
rl129 n37__clk_b n38__clk_b 69.2328
rl130 n38__clk_b n39__clk_b 111.54
rl131 n42__rst n43__rst 38.1757
rl132 n43__rst n44__rst 49.3144
rl133 n43__rst n45__rst 80.4834
rl134 n45__rst n46__rst 111.54
rl135 n30__rst_b n31__rst_b 126.923
rl136 n31__rst_b n32__rst_b 69.2328
rl137 i25__x n2__i25__x 99.7141
rl138 n2__i25__x n3__i25__x 50.1123
rl139 n2__i25__x n4__i25__x 65.0987
rl140 n41__clk_b n42__clk_b 71.1559
rl141 n38__clk n39__clk 69.2328
rl142 n39__clk n40__clk 111.54
rl143 i23__net1 n2__i23__net1 72.3097
rl144 n2__i23__net1 n3__i23__net1 72.3097
rl145 n42__clk n43__clk 71.1559
rl146 n48__clk_b n49__clk_b 69.2328
rl147 n49__clk_b n50__clk_b 111.54
rl148 n58__rst n59__rst 38.1757
rl149 n59__rst n60__rst 49.3144
rl150 n59__rst n61__rst 80.4834
rl151 n61__rst n62__rst 111.54
rl152 n40__rst_b n41__rst_b 126.923
rl153 n41__rst_b n42__rst_b 69.2328
rl154 i23__x n2__i23__x 99.7141
rl155 n2__i23__x n3__i23__x 50.1123
rl156 n2__i23__x n4__i23__x 65.0987
rl157 n52__clk_b n53__clk_b 71.1559
rl158 n48__clk n49__clk 69.2328
rl159 n49__clk n50__clk 111.54
rl160 i30__net1 n2__i30__net1 72.3097
rl161 n2__i30__net1 n3__i30__net1 72.3097
rl162 n52__clk n53__clk 71.1559
rl163 n59__clk_b n60__clk_b 69.2328
rl164 n60__clk_b n61__clk_b 111.54
rl165 n74__rst n75__rst 38.1757
rl166 n75__rst n76__rst 49.3144
rl167 n75__rst n77__rst 80.4834
rl168 n77__rst n78__rst 111.54
rl169 n50__rst_b n51__rst_b 126.923
rl170 n51__rst_b n52__rst_b 69.2328
rl171 i30__x n2__i30__x 99.7141
rl172 n2__i30__x n3__i30__x 50.1123
rl173 n2__i30__x n4__i30__x 65.0987
rl174 n63__clk_b n64__clk_b 71.1559
rl175 n58__clk n59__clk 69.2328
rl176 n59__clk n60__clk 111.54
rl177 i20__net1 n2__i20__net1 72.3097
rl178 n2__i20__net1 n3__i20__net1 72.3097
rl179 n62__clk n63__clk 71.1559
rl180 n70__clk_b n71__clk_b 69.2328
rl181 n71__clk_b n72__clk_b 111.54
rl182 n90__rst n91__rst 38.1757
rl183 n91__rst n92__rst 49.3144
rl184 n91__rst n93__rst 80.4834
rl185 n93__rst n94__rst 111.54
rl186 n60__rst_b n61__rst_b 126.923
rl187 n61__rst_b n62__rst_b 69.2328
rl188 i20__x n2__i20__x 99.7141
rl189 n2__i20__x n3__i20__x 50.1123
rl190 n2__i20__x n4__i20__x 65.0987
rl191 n74__clk_b n75__clk_b 71.1559
rl192 n68__clk n69__clk 69.2328
rl193 n69__clk n70__clk 111.54
rl194 i21__net1 n2__i21__net1 72.3097
rl195 n2__i21__net1 n3__i21__net1 72.3097
rl196 n72__clk n73__clk 71.1559
rl197 n81__clk_b n82__clk_b 69.2328
rl198 n82__clk_b n83__clk_b 111.54
rl199 n106__rst n107__rst 38.1757
rl200 n107__rst n108__rst 49.3144
rl201 n107__rst n109__rst 80.4834
rl202 n109__rst n110__rst 111.54
rl203 n70__rst_b n71__rst_b 126.923
rl204 n71__rst_b n72__rst_b 69.2328
rl205 i21__x n2__i21__x 99.7141
rl206 n2__i21__x n3__i21__x 50.1123
rl207 n2__i21__x n4__i21__x 65.0987
rl208 n85__clk_b n86__clk_b 71.1559
rl209 n78__clk n79__clk 69.2328
rl210 n79__clk n80__clk 111.54
rl211 i19__net1 n2__i19__net1 72.3097
rl212 n2__i19__net1 n3__i19__net1 72.3097
rl213 n82__clk n83__clk 71.1559
rl214 n92__clk_b n93__clk_b 69.2328
rl215 n93__clk_b n94__clk_b 111.54
rl216 n122__rst n123__rst 38.1757
rl217 n123__rst n124__rst 49.3144
rl218 n123__rst n125__rst 80.4834
rl219 n125__rst n126__rst 111.54
rl220 n80__rst_b n81__rst_b 126.923
rl221 n81__rst_b n82__rst_b 69.2328
rl222 i19__x n2__i19__x 99.7141
rl223 n2__i19__x n3__i19__x 50.1123
rl224 n2__i19__x n4__i19__x 65.0987
rl225 n96__clk_b n97__clk_b 71.1559
rl226 n88__clk n89__clk 69.2328
rl227 n89__clk n90__clk 111.54
rl228 i22__net1 n2__i22__net1 72.3097
rl229 n2__i22__net1 n3__i22__net1 72.3097
rl230 n92__clk n93__clk 71.1559
rl231 n103__clk_b n104__clk_b 69.2328
rl232 n104__clk_b n105__clk_b 111.54
rl233 n138__rst n139__rst 38.1757
rl234 n139__rst n140__rst 49.3144
rl235 n139__rst n141__rst 80.4834
rl236 n141__rst n142__rst 111.54
rl237 n90__rst_b n91__rst_b 126.923
rl238 n91__rst_b n92__rst_b 69.2328
rl239 i22__x n2__i22__x 99.7141
rl240 n2__i22__x n3__i22__x 50.1123
rl241 n2__i22__x n4__i22__x 65.0987
rl242 n107__clk_b n108__clk_b 71.1559
rl243 n98__clk n99__clk 69.2328
rl244 n99__clk n100__clk 111.54
rl245 i17__net1 n2__i17__net1 72.3097
rl246 n2__i17__net1 n3__i17__net1 72.3097
rl247 n102__clk n103__clk 71.1559
rl248 n114__clk_b n115__clk_b 69.2328
rl249 n115__clk_b n116__clk_b 111.54
rl250 n154__rst n155__rst 38.1757
rl251 n155__rst n156__rst 49.3144
rl252 n155__rst n157__rst 80.4834
rl253 n157__rst n158__rst 111.54
rl254 n100__rst_b n101__rst_b 126.923
rl255 n101__rst_b n102__rst_b 69.2328
rl256 i17__x n2__i17__x 99.7141
rl257 n2__i17__x n3__i17__x 50.1123
rl258 n2__i17__x n4__i17__x 65.0987
rl259 n118__clk_b n119__clk_b 71.1559
rl260 n108__clk n109__clk 69.2328
rl261 n109__clk n110__clk 111.54
rl262 i18__net1 n2__i18__net1 72.3097
rl263 n2__i18__net1 n3__i18__net1 72.3097
rl264 n112__clk n113__clk 71.1559
rl265 n127__clk_b n128__clk_b 69.2328
rl266 n128__clk_b n129__clk_b 111.54
rl267 n170__rst n171__rst 38.1757
rl268 n171__rst n172__rst 49.3144
rl269 n171__rst n173__rst 80.4834
rl270 n173__rst n174__rst 111.54
rl271 n110__rst_b n111__rst_b 126.923
rl272 n111__rst_b n112__rst_b 69.2328
rl273 i18__x n2__i18__x 99.7141
rl274 n2__i18__x n3__i18__x 50.1123
rl275 n2__i18__x n4__i18__x 65.0987
rl276 n131__clk_b n132__clk_b 71.1559
rl277 n119__clk n120__clk 69.2328
rl278 n120__clk n121__clk 111.54
rl279 i16__net1 n2__i16__net1 72.3097
rl280 n2__i16__net1 n3__i16__net1 72.3097
rl281 n123__clk n124__clk 71.1559
rl282 n138__clk_b n139__clk_b 69.2328
rl283 n139__clk_b n140__clk_b 111.54
rl284 n186__rst n187__rst 38.1757
rl285 n187__rst n188__rst 49.3144
rl286 n187__rst n189__rst 80.4834
rl287 n189__rst n190__rst 111.54
rl288 n120__rst_b n121__rst_b 126.923
rl289 n121__rst_b n122__rst_b 69.2328
rl290 i16__x n2__i16__x 99.7141
rl291 n2__i16__x n3__i16__x 50.1123
rl292 n2__i16__x n4__i16__x 65.0987
rl293 n142__clk_b n143__clk_b 71.1559
rl294 n129__clk n130__clk 69.2328
rl295 n130__clk n131__clk 111.54
rl296 i0__net1 n2__i0__net1 72.3097
rl297 n2__i0__net1 n3__i0__net1 72.3097
rl298 n133__clk n134__clk 71.1559
rl299 n149__clk_b n150__clk_b 69.2328
rl300 n150__clk_b n151__clk_b 111.54
rl301 n202__rst n203__rst 38.1757
rl302 n203__rst n204__rst 49.3144
rl303 n203__rst n205__rst 80.4834
rl304 n205__rst n206__rst 111.54
rl305 n130__rst_b n131__rst_b 126.923
rl306 n131__rst_b n132__rst_b 69.2328
rl307 i0__x n2__i0__x 99.7141
rl308 n2__i0__x n3__i0__x 50.1123
rl309 n2__i0__x n4__i0__x 65.0987
rl310 n153__clk_b n154__clk_b 71.1559
rl311 n139__clk n140__clk 69.2328
rl312 n140__clk n141__clk 111.54
mi58__i2__pm0 n7__i58__net2 n3__q12 n92__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi58__i3__pm0 n16__i58__net1 n9__q3 n55__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi58__i1__pm0 n8__xor1 i58__net1 n3__i58__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi58__i0__pm0 n5__q12 n1__q3 n8__xor1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i2__pm0 n3__i56__net2 n4__xor1 n91__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i3__pm0 n9__i56__net1 n3__xor2 n90__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i1__pm0 n4__d0 i56__net1 n7__i56__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i0__pm0 n14__xor1 n9__xor2 n4__d0 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i2__pm0 n5__i57__net2 n4__q14 n94__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i3__pm0 n14__i57__net1 n7__q15 n95__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i1__pm0 n11__xor2 n6__i57__net1 i57__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i0__pm0 n5__q14 n1__q15 n11__xor2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__pm0 i0__net2 i0__net1 n58__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__pm1 n7__i0__x n133__clk i0__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__i6__i1__pm0 n10__i0__net1 n202__rst n6__d0 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__i6__i0__pm0 n245__rst n131__rst_b n10__i0__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__pm2 i0__net4 i0__x n56__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__pm3 n9__q0 n153__clk_b i0__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__pm0 i16__net2 i16__net1 n60__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__pm1 n7__i16__x n123__clk i16__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__i6__i1__pm0 n10__i16__net1 n186__rst n2__q0 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__i6__i0__pm0 n236__rst n121__rst_b n10__i16__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__pm2 i16__net4 i16__x n59__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__pm3 n9__q1 n142__clk_b i16__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__pm0 i18__net2 i18__net1 n62__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__pm1 n7__i18__x n112__clk i18__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__i6__i1__pm0 n10__i18__net1 n170__rst n2__q1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__i6__i0__pm0 n227__rst n111__rst_b n10__i18__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__pm2 i18__net4 i18__x n61__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__pm3 n9__q2 n131__clk_b i18__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__pm0 i17__net2 i17__net1 n64__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__pm1 n7__i17__x n102__clk i17__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__i6__i1__pm0 n10__i17__net1 n154__rst n2__q2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__i6__i0__pm0 n218__rst n101__rst_b n10__i17__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__pm2 i17__net4 i17__x n63__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__pm3 n25__q3 n118__clk_b i17__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__pm0 i22__net2 i22__net1 n66__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__pm1 n7__i22__x n92__clk i22__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__i6__i1__pm0 n11__i22__net1 n138__rst n16__q3 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__i6__i0__pm0 n209__rst n91__rst_b n11__i22__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__pm2 i22__net4 i22__x n65__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__pm3 n14__q4 n107__clk_b i22__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__pm0 i19__net2 i19__net1 n68__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__pm1 n7__i19__x n82__clk i19__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i6__i1__pm0 n11__i19__net1 n122__rst n2__q4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i6__i0__pm0 n193__rst n81__rst_b n11__i19__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__pm2 i19__net4 i19__x n67__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__pm3 n13__q5 n96__clk_b i19__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__pm0 i21__net2 i21__net1 n70__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__pm1 n7__i21__x n72__clk i21__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__i6__i1__pm0 n11__i21__net1 n106__rst n2__q5 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__i6__i0__pm0 n177__rst n71__rst_b n11__i21__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__pm2 i21__net4 i21__x n69__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__pm3 n13__q6 n85__clk_b i21__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__pm0 i20__net2 i20__net1 n72__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__pm1 n7__i20__x n62__clk i20__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i6__i1__pm0 n11__i20__net1 n90__rst n2__q6 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i6__i0__pm0 n161__rst n61__rst_b n11__i20__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__pm2 i20__net4 i20__x n71__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__pm3 n13__q7 n74__clk_b i20__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__pm0 i30__net2 i30__net1 n74__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__pm1 n7__i30__x n52__clk i30__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__i6__i1__pm0 n11__i30__net1 n74__rst n2__q7 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__i6__i0__pm0 n145__rst n51__rst_b n11__i30__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__pm2 i30__net4 i30__x n73__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__pm3 n13__q8 n63__clk_b i30__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__pm0 i23__net2 i23__net1 n76__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__pm1 n7__i23__x n42__clk i23__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__i6__i1__pm0 n11__i23__net1 n58__rst n2__q8 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__i6__i0__pm0 n129__rst n41__rst_b n11__i23__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__pm2 i23__net4 i23__x n75__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__pm3 n13__q9 n52__clk_b i23__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__pm0 i25__net2 i25__net1 n78__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__pm1 n7__i25__x n32__clk i25__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__i6__i1__pm0 n11__i25__net1 n42__rst n2__q9 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__i6__i0__pm0 n113__rst n31__rst_b n11__i25__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__pm2 i25__net4 i25__x n77__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__pm3 n13__q10 n41__clk_b i25__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__pm0 i24__net2 i24__net1 n80__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__pm1 n7__i24__x n22__clk i24__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__i6__i1__pm0 n11__i24__net1 n26__rst n2__q10 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__i6__i0__pm0 n97__rst n21__rst_b n11__i24__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__pm2 i24__net4 i24__x n79__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__pm3 n13__q11 n30__clk_b i24__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__pm0 i29__net2 i29__net1 n82__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__pm1 n7__i29__x n16__clk i29__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i6__i1__pm0 n11__i29__net1 n16__rst n2__q11 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i6__i0__pm0 n81__rst n11__rst_b n11__i29__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__pm2 i29__net4 i29__x n81__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__pm3 n25__q12 n19__clk_b i29__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__pm0 i26__net2 i26__net1 n84__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__pm1 n7__i26__x n11__clk i26__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__i6__i1__pm0 n11__i26__net1 n11__rst n14__q12 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__i6__i0__pm0 n65__rst n8__rst_b n11__i26__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__pm2 i26__net4 i26__x n83__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__pm3 n13__q13 n14__clk_b i26__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__pm0 i28__net2 i28__net1 n86__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__pm1 n7__i28__x n6__clk i28__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i6__i1__pm0 n11__i28__net1 n6__rst n2__q13 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i6__i0__pm0 n49__rst n5__rst_b n11__i28__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__pm2 i28__net4 i28__x n85__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__pm3 n24__q14 n9__clk_b i28__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__pm0 i27__net2 i27__net1 n88__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__pm1 n7__i27__x n1__clk i27__net2 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__i6__i1__pm0 n11__i27__net1 n1__rst n15__q14 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__i6__i0__pm0 n33__rst n2__rst_b n11__i27__net1 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__pm2 i27__net4 i27__x n87__vdd n57__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__pm3 n12__q15 n4__clk_b i27__net4 n57__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi58__i2__nm0 n5__i58__net2 n4__q12 n62__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi58__i3__nm0 n14__i58__net1 n7__q3 n23__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi58__i1__nm0 n6__xor1 n5__q3 i58__net2 n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi58__i0__nm0 n7__q12 n4__i58__net1 n6__xor1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i2__nm0 i56__net2 xor1 n61__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i3__nm0 n7__i56__net1 n2__xor2 n60__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i1__nm0 d0 n7__xor2 n5__i56__net2 n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi56__i0__nm0 n16__xor1 n5__i56__net1 d0 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i2__nm0 n7__i57__net2 n3__q14 n94__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i3__nm0 n16__i57__net1 n8__q15 n58__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i1__nm0 n13__xor2 n6__q15 n3__i57__net2 n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__i0__nm0 n7__q14 i57__net1 n13__xor2 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__nm2 n11__q0 n140__clk i0__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__nm3 i0__net5 n4__i0__x n1__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__nm0 n6__i0__x n150__clk_b i0__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__nm1 i0__net3 n3__i0__net1 n63__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__i6__i1__nm0 n11__d0 n130__rst_b n8__i0__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__i6__i0__nm0 n8__i0__net1 n205__rst n240__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__nm2 n11__q1 n130__clk i16__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__nm3 i16__net5 n4__i16__x n64__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__nm0 n6__i16__x n139__clk_b i16__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__nm1 i16__net3 n3__i16__net1 n65__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__i6__i1__nm0 n8__q0 n120__rst_b n8__i16__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi16__i6__i0__nm0 n8__i16__net1 n189__rst n231__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__nm2 n11__q2 n120__clk i18__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__nm3 i18__net5 n4__i18__x n66__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__nm0 n6__i18__x n128__clk_b i18__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__nm1 i18__net3 n3__i18__net1 n67__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__i6__i1__nm0 n8__q1 n110__rst_b n8__i18__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi18__i6__i0__nm0 n8__i18__net1 n173__rst n222__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__nm2 n27__q3 n109__clk i17__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__nm3 i17__net5 n4__i17__x n68__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__nm0 n6__i17__x n115__clk_b i17__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__nm1 i17__net3 n3__i17__net1 n69__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__i6__i1__nm0 n8__q2 n100__rst_b n8__i17__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi17__i6__i0__nm0 n8__i17__net1 n157__rst n213__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__nm2 n16__q4 n99__clk i22__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__nm3 i22__net5 n4__i22__x n70__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__nm0 n6__i22__x n104__clk_b i22__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__nm1 i22__net3 n3__i22__net1 n71__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__i6__i1__nm0 n24__q3 n90__rst_b n9__i22__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi22__i6__i0__nm0 n9__i22__net1 n141__rst n197__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__nm2 n15__q5 n89__clk i19__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__nm3 i19__net5 n4__i19__x n72__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__nm0 n6__i19__x n93__clk_b i19__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__nm1 i19__net3 n3__i19__net1 n73__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i6__i1__nm0 n8__q4 n80__rst_b n9__i19__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi19__i6__i0__nm0 n9__i19__net1 n125__rst n181__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__nm2 n15__q6 n79__clk i21__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__nm3 i21__net5 n4__i21__x n74__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__nm0 n6__i21__x n82__clk_b i21__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__nm1 i21__net3 n3__i21__net1 n75__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__i6__i1__nm0 n8__q5 n70__rst_b n9__i21__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi21__i6__i0__nm0 n9__i21__net1 n109__rst n165__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__nm2 n15__q7 n69__clk i20__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__nm3 i20__net5 n4__i20__x n76__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__nm0 n6__i20__x n71__clk_b i20__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__nm1 i20__net3 n3__i20__net1 n77__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i6__i1__nm0 n8__q6 n60__rst_b n9__i20__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi20__i6__i0__nm0 n9__i20__net1 n93__rst n149__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__nm2 n15__q8 n59__clk i30__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__nm3 i30__net5 n4__i30__x n78__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__nm0 n6__i30__x n60__clk_b i30__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__nm1 i30__net3 n3__i30__net1 n79__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__i6__i1__nm0 n8__q7 n50__rst_b n9__i30__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi30__i6__i0__nm0 n9__i30__net1 n77__rst n133__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__nm2 n15__q9 n49__clk i23__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__nm3 i23__net5 n4__i23__x n80__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__nm0 n6__i23__x n49__clk_b i23__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__nm1 i23__net3 n3__i23__net1 n81__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__i6__i1__nm0 n8__q8 n40__rst_b n9__i23__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi23__i6__i0__nm0 n9__i23__net1 n61__rst n117__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__nm2 n15__q10 n39__clk i25__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__nm3 i25__net5 n4__i25__x n82__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__nm0 n6__i25__x n38__clk_b i25__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__nm1 i25__net3 n3__i25__net1 n83__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__i6__i1__nm0 n8__q9 n30__rst_b n9__i25__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi25__i6__i0__nm0 n9__i25__net1 n45__rst n101__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__nm2 n15__q11 n29__clk i24__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__nm3 i24__net5 n4__i24__x n84__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__nm0 n6__i24__x n27__clk_b i24__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__nm1 i24__net3 n3__i24__net1 n85__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__i6__i1__nm0 n8__q10 n20__rst_b n9__i24__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi24__i6__i0__nm0 n9__i24__net1 n29__rst n85__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__nm2 n27__q12 n19__clk i29__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__nm3 i29__net5 n4__i29__x n86__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__nm0 n6__i29__x n17__clk_b i29__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__nm1 i29__net3 n3__i29__net1 n87__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i6__i1__nm0 n8__q11 n10__rst_b n9__i29__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi29__i6__i0__nm0 n9__i29__net1 n19__rst n69__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__nm2 n15__q13 n14__clk i26__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__nm3 i26__net5 n4__i26__x n88__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__nm0 n6__i26__x n12__clk_b i26__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__nm1 i26__net3 n3__i26__net1 n89__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__i6__i1__nm0 n20__q12 n7__rst_b n9__i26__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi26__i6__i0__nm0 n9__i26__net1 n14__rst n53__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__nm2 n26__q14 n9__clk i28__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__nm3 i28__net5 n4__i28__x n90__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__nm0 n6__i28__x n7__clk_b i28__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__nm1 i28__net3 n3__i28__net1 n91__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i6__i1__nm0 n8__q13 n4__rst_b n9__i28__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi28__i6__i0__nm0 n9__i28__net1 n9__rst n37__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__nm2 n14__q15 n4__clk i27__net5 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__nm3 i27__net5 n4__i27__x n92__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__nm0 n6__i27__x n2__clk_b i27__net3 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__nm1 i27__net3 n3__i27__net1 n93__vss n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__i6__i1__nm0 n21__q14 n1__rst_b n9__i27__net1 n59__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi27__i6__i0__nm0 n9__i27__net1 n4__rst n21__rst n59__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
.END
