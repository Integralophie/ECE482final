** Generated for: hspiceD
** Generated on: Dec  4 18:56:38 2023
** Design library name: ECE482final_cadence
** Design cell name: decoder
** Design view name: av_extracted

.TEMP 25.0
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2

** Library name: ECE482final_cadence
** Cell name: decoder
** View name: av_extracted
c1 vdd vss 40.8051e-18
c2 s0 vss 15.2703e-18
c3 s0_b vss 51.2033e-18
c4 out1 vss 25.0731e-18
c5 out2 vss 47.9759e-18
c6 in vss 76.288e-18
c7 n4__s0 vss 33.5908e-18
c8 n1__s0_b vss 42.7982e-18
c9 n3__s0 vss 30.9288e-18
c10 n4__s0_b vss 24.4468e-18
c11 n1__s0 vss 12.8802e-18
c12 n3__s0_b vss 84.7843e-18
c13 n8__out1 vss 30.9326e-18
c14 n7__out1 vss 27.5385e-18
c15 n5__out2 vss 91.539e-18
c16 n4__out1 vss 162.079e-18
c17 n6__s0 vss 183.457e-18
c18 n1__out1 vss 140.658e-18
c19 n3__out2 vss 117.353e-18
c20 n5__s0 vss 168.181e-18
c21 n3__vdd vss 259.286e-18
c22 n2__in vss 48.1993e-18
c23 n1__out2 vss 77.0771e-18
c24 n6__out2 vss 32.4864e-18
c25 n3__in vss 79.5765e-18
c26 n2__s0_b vss 20.1655e-18
c27 n2__s0 vss 17.9121e-18
c28 n4__out2 vss 36.7232e-18
c29 n1__in vss 72.385e-18
c30 n2__vdd vss 34.2435e-18
ri1 n8__out1 n7__out1 404.7e-3
rj1 n1__out1 n7__out1 1
rj2 n6__s0 n5__s0 815.9e-3
rj3 n4__out1 n8__out1 1
rj4 n5__out2 n3__out2 1.0764
rk1 out2 n2__out2 108.3e-3
rk2 n2__out2 n3__out2 504.9e-3
rk3 n1__out2 n2__out2 75
rk4 n5__s0 s0 523.5e-3
rk5 n1__out1 n3__out1 13.61e-3
rk6 n3__out1 out1 152.7e-3
rk7 n2__out1 n3__out1 31
rk8 n3__s0_b s0_b 249.5e-3
rk9 n4__out2 n5__out2 2.671e-3
rk10 n7__out2 n8__out2 2.671e-3
rk11 n4__out2 n8__out2 15.75e-3
rk12 n6__out2 n7__out2 31
rk13 n4__out1 n6__out1 7.059e-3
rk14 n5__out1 n6__out1 75
rk15 n6__s0 n1__s0 3.784e-3
rk16 in n1__in 354.1e-3
rk17 n1__in n2__in 75.1319
rk18 n1__in n3__in 31.2815
rk20 n2__vdd vdd 604.1e-3
rk21 n2__vdd n3__vdd 75.107
rk23 n2__vss vss 679.1e-3
rk24 n2__vss n3__vss 62.0778
rl1 n1__s0_b n2__s0_b 84.3295
rl2 n2__s0_b n3__s0_b 50.1123
rl3 n2__s0_b n4__s0_b 34.3295
rl4 n1__s0 n2__s0 49.3192
rl5 n2__s0 n3__s0 80.4834
rl6 n2__s0 n4__s0 38.1757
mi0__pm0 n3__in n1__s0_b n2__out1 n3__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__pm0 n6__out2 n4__s0 n3__in n3__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__nm0 n2__in n4__s0_b n1__out2 n3__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__nm0 n5__out1 n3__s0 n2__in n3__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
.END
