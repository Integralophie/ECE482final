** Generated for: hspiceD
** Generated on: Nov 11 14:59:22 2023
** Design library name: ECE482final_cadence
** Design cell name: c2mos_register
** Design view name: schematic

.TEMP 25.0
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2

** Library name: ECE482final_cadence
** Cell name: c2mos_register
** View name: schematic
.lib '/class/ece482/gpdk045_mos' TT
cx      x      vss 2fF
cnet2   net2   vss 2fF
cnet3   net3   vss 2fF
cnet4   net4   vss 2fF
cnet5   net5   vss 2fF
cd      d      vss 2fF
cq      q      vss 10fF
cclk    clk    vss 2fF
cclkbar clkbar vss 2fF

mpm3 q clkbar net4 vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=583.333e-3 NRS=583.333e-3 M=1
mpm2 net4 x vdd vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=583.333e-3 NRS=583.333e-3 M=1
mpm1 x clk net2 vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=583.333e-3 NRS=583.333e-3 M=1
mpm0 net2 d vdd vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=583.333e-3 NRS=583.333e-3 M=1
mnm3 net5 x vss vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mnm1 net3 d vss vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mnm2 q clk net5 vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mnm0 x clkbar net3 vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1

** Power voltages
vvss    vss    0 0
vvdd    vdd    0 1.1

** Clock stimulus
vclk    clk    0 pulse(0 1.1 2.5ns 15ps 15ps 5ns 10ns)
vclkbar clkbar 0 pulse(1.1 0 2.5ns 15ps 15ps 5ns 10ns)

** Data Stimulation
vd      d      0 pwl(0ns 0 9.985ns 0 10ns 1.1 19.985ns 1.1 20ns 0)

.tran 0.01ps 50ns
.option post
.END
