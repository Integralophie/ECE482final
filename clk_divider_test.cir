clkdivider
.lib '/class/ece482/gpdk045_mos' TT

c1 vdd vss 5.66982e-18
c2 clk1pt6g vss 11.1602e-18
c3 clk1pt6g_b vss 13.3534e-18
c4 clk100m vss 40.5168e-18
c5 clk100m_b vss 73.8233e-18
c6 net7 vss 40.7121e-18
c7 net2 vss 13.9676e-18
c8 i50__net1 vss 25.0404e-18
c9 i50__net2 vss 184.975e-18
c10 net8 vss 29.1203e-18
c11 net10 vss 62.2386e-18
c12 net4 vss 89.524e-18
c13 net14 vss 79.5789e-18
c14 net9 vss 26.0074e-18
c15 net1 vss 37.8716e-18
c16 net6 vss 52.7452e-18
c17 net15 vss 35.4918e-18
c18 net3 vss 31.19e-18
c19 net20 vss 24.2421e-18
c20 net17 vss 38.025e-18
c21 net12 vss 24.4039e-18
c22 net23 vss 26.9154e-18
c23 net19 vss 37.076e-18
c24 net13 vss 24.8932e-18
c25 net26 vss 318.6e-18
c26 net5 vss 38.7983e-18
c27 net11 vss 20.5509e-18
c28 avs133 vss 271.161e-18
c29 i53__net5 vss 36.9328e-18
c30 i53__net4 vss 80.997e-18
c31 i53__x vss 57.1285e-18
c32 i53__net2 vss 52.9485e-18
c33 i53__net3 vss 32.3541e-18
c34 i51__net5 vss 37.6249e-18
c35 i51__net4 vss 75.058e-18
c36 i51__x vss 38.7106e-18
c37 i51__net2 vss 151.606e-18
c38 i51__net3 vss 39.104e-18
c39 i72__net5 vss 37.6186e-18
c40 i72__net4 vss 76.9768e-18
c41 i72__x vss 37.7354e-18
c42 i72__net2 vss 155.266e-18
c43 i72__net3 vss 39.391e-18
c44 i71__net5 vss 37.6249e-18
c45 i71__net4 vss 76.3781e-18
c46 i71__x vss 36.3624e-18
c47 i71__net2 vss 154.146e-18
c48 i71__net3 vss 39.2324e-18
c49 i70__net5 vss 37.7274e-18
c50 i70__net4 vss 77.2891e-18
c51 i70__x vss 36.6712e-18
c52 i70__net2 vss 155.306e-18
c53 i70__net3 vss 39.1046e-18
c54 i52__net5 vss 40.5927e-18
c55 i52__net4 vss 78.6055e-18
c56 i52__x vss 56.723e-18
c57 i52__net2 vss 47.0959e-18
c58 i52__net3 vss 32.4058e-18
c59 i69__net5 vss 37.6249e-18
c60 i69__net4 vss 76.1295e-18
c61 i69__x vss 37.2515e-18
c62 i69__net2 vss 149.763e-18
c63 i69__net3 vss 39.3764e-18
c64 n15__net6 vss 26.0805e-18
c65 n14__net6 vss 29.4855e-18
c66 n6__net6 vss 27.0478e-18
c67 n5__net6 vss 34.1979e-18
c68 n29__net13 vss 29.9869e-18
c69 n26__net13 vss 14.4688e-18
c70 n39__clk1pt6g vss 14.9183e-18
c71 n37__clk1pt6g vss 28.4158e-18
c72 n6__i51__x vss 26.8582e-18
c73 n6__i52__x vss 27.5429e-18
c74 n5__i52__x vss 33.6913e-18
c75 n6__net11 vss 29.4671e-18
c76 n3__net11 vss 14.5796e-18
c77 n34__clk1pt6g_b vss 14.8254e-18
c78 n32__clk1pt6g_b vss 28.2845e-18
c79 n6__net5 vss 27.9083e-18
c80 n12__net7 vss 27.9701e-18
c81 n11__net7 vss 33.7335e-18
c82 n16__net13 vss 27.3904e-18
c83 n27__clk1pt6g vss 14.9231e-18
c84 n17__net13 vss 24.9237e-18
c85 n25__clk1pt6g vss 28.3591e-18
c86 n3__net13 vss 12.224e-18
c87 n6__i53__x vss 27.5429e-18
c88 n13__net13 vss 15.8675e-18
c89 n5__i53__x vss 33.5395e-18
c90 n29__net12 vss 29.941e-18
c91 n22__clk1pt6g_b vss 14.8204e-18
c92 n26__net12 vss 14.4688e-18
c93 n20__clk1pt6g_b vss 27.6925e-18
c94 n11__net8 vss 45.453e-18
c95 n6__i72__x vss 29.3227e-18
c96 n6__net8 vss 35.3563e-18
c97 n6__net26 vss 29.6209e-18
c98 n3__net26 vss 14.5795e-18
c99 n6__net7 vss 43.1004e-18
c100 n4__i50__net1 vss 40.1382e-18
c101 n6__net19 vss 29.4124e-18
c102 n6__i50__net1 vss 39.6853e-18
c103 n16__net12 vss 26.2117e-18
c104 n15__net8 vss 45.1596e-18
c105 n17__net12 vss 25.5013e-18
c106 n9__net8 vss 46.715e-18
c107 n3__net12 vss 12.2239e-18
c108 n13__net12 vss 15.8655e-18
c109 n7__net2 vss 24.809e-18
c110 n6__net2 vss 27.5946e-18
c111 n24__net3 vss 43.5142e-18
c112 n27__net3 vss 14.4859e-18
c113 n7__net4 vss 39.1583e-18
c114 n6__net4 vss 37.9802e-18
c115 n6__i71__x vss 28.7892e-18
c116 n22__net10 vss 59.4082e-18
c117 n18__net10 vss 32.5557e-18
c118 n6__net23 vss 29.657e-18
c119 n10__net10 vss 32.7105e-18
c120 n3__net23 vss 14.5796e-18
c121 n8__net10 vss 59.1757e-18
c122 n49__net14 vss 55.8631e-18
c123 n6__net17 vss 28.9091e-18
c124 n45__net14 vss 32.5483e-18
c125 n37__net14 vss 32.6821e-18
c126 n33__net14 vss 32.6929e-18
c127 n16__net3 vss 29.3042e-18
c128 n25__net14 vss 32.6947e-18
c129 n17__net3 vss 26.0471e-18
c130 n21__net14 vss 32.7022e-18
c131 n13__net14 vss 32.724e-18
c132 n3__net3 vss 12.2239e-18
c133 n11__net14 vss 59.161e-18
c134 n13__net3 vss 15.8654e-18
c135 n49__clk100m vss 55.8631e-18
c136 n29__net9 vss 29.9027e-18
c137 n45__clk100m vss 32.5483e-18
c138 n26__net9 vss 14.4688e-18
c139 n37__clk100m vss 32.6821e-18
c140 n33__clk100m vss 32.6929e-18
c141 n25__clk100m vss 32.7037e-18
c142 n6__i70__x vss 29.0031e-18
c143 n21__clk100m vss 32.7186e-18
c144 n13__clk100m vss 35.1161e-18
c145 n6__net20 vss 29.657e-18
c146 n11__clk100m vss 67.5186e-18
c147 n3__net20 vss 14.5796e-18
c148 n6__net15 vss 26.9562e-18
c149 n16__net9 vss 27.8966e-18
c150 n17__net9 vss 25.2849e-18
c151 n3__net9 vss 12.2239e-18
c152 n13__net9 vss 15.8484e-18
c153 n11__clk1pt6g_b vss 29.9207e-18
c154 n8__clk1pt6g_b vss 14.5724e-18
c155 n6__i69__x vss 29.3909e-18
c156 n6__clk1pt6g vss 29.4873e-18
c157 n3__clk1pt6g vss 14.6167e-18
c158 n6__net1 vss 29.492e-18
c159 n11__net6 vss 24.6755e-18
c160 n12__net6 vss 27.2416e-18
c161 n2__net6 vss 22.0822e-18
c162 n3__net6 vss 28.7132e-18
c163 n8__net11 vss 37.9504e-18
c164 n9__net11 vss 22.1136e-18
c165 n39__clk1pt6g_b vss 23.7254e-18
c166 n40__clk1pt6g_b vss 23.666e-18
c167 n3__i51__x vss 28.5398e-18
c168 n4__i51__x vss 25.4835e-18
c169 n2__i52__x vss 25.1074e-18
c170 n3__i52__x vss 27.9136e-18
c171 n19__net13 vss 37.7786e-18
c172 n20__net13 vss 23.4231e-18
c173 n32__clk1pt6g vss 23.6853e-18
c174 n33__clk1pt6g vss 21.5324e-18
c175 n3__net5 vss 30.017e-18
c176 n4__net5 vss 24.5847e-18
c177 n8__net7 vss 25.1133e-18
c178 n9__net7 vss 27.8656e-18
c179 n10__net13 vss 24.3582e-18
c180 n27__clk1pt6g_b vss 21.6113e-18
c181 n9__net13 vss 23.0127e-18
c182 n28__clk1pt6g_b vss 22.6089e-18
c183 n5__net13 vss 21.3035e-18
c184 n2__i53__x vss 26.7209e-18
c185 n6__net13 vss 27.1742e-18
c186 n3__i53__x vss 28.0804e-18
c187 n8__net26 vss 37.9387e-18
c188 n20__clk1pt6g vss 22.5187e-18
c189 n9__net26 vss 22.1136e-18
c190 n21__clk1pt6g vss 20.211e-18
c191 n3__i72__x vss 28.5398e-18
c192 n13__net8 vss 20.5584e-18
c193 n4__i72__x vss 25.4835e-18
c194 n4__net8 vss 18.5043e-18
c195 n19__net12 vss 37.7786e-18
c196 n5__net7 vss 31.6909e-18
c197 n20__net12 vss 23.4231e-18
c198 n4__net7 vss 33.6278e-18
c199 n3__net19 vss 30.017e-18
c200 n4__net19 vss 24.5842e-18
c201 n10__net8 vss 40.3242e-18
c202 n10__net12 vss 24.388e-18
c203 n9__net12 vss 23.0127e-18
c204 n3__i50__net1 vss 26.9783e-18
c205 n5__net12 vss 21.548e-18
c206 n6__net12 vss 27.1742e-18
c207 n3__net2 vss 24.5413e-18
c208 n4__net2 vss 23.7284e-18
c209 n8__net23 vss 37.9695e-18
c210 n9__net23 vss 22.1136e-18
c211 n3__net4 vss 32.6209e-18
c212 n4__net4 vss 29.7805e-18
c213 n3__i71__x vss 28.5398e-18
c214 n4__i71__x vss 25.4835e-18
c215 n3__net10 vss 42.3793e-18
c216 n16__net10 vss 16.5962e-18
c217 n19__net3 vss 37.7788e-18
c218 n12__net10 vss 16.6519e-18
c219 n20__net3 vss 23.4233e-18
c220 n6__net10 vss 43.0626e-18
c221 n3__net17 vss 30.0177e-18
c222 n2__net14 vss 37.901e-18
c223 n4__net17 vss 24.6429e-18
c224 n43__net14 vss 16.5889e-18
c225 n39__net14 vss 16.6506e-18
c226 n31__net14 vss 16.6433e-18
c227 n10__net3 vss 24.4354e-18
c228 n27__net14 vss 16.6433e-18
c229 n9__net3 vss 23.0168e-18
c230 n19__net14 vss 16.6506e-18
c231 n15__net14 vss 16.6447e-18
c232 n5__net3 vss 21.5467e-18
c233 n9__net14 vss 41.4784e-18
c234 n6__net3 vss 27.1742e-18
c235 n2__clk100m vss 37.7636e-18
c236 n8__net20 vss 37.9387e-18
c237 n43__clk100m vss 16.5889e-18
c238 n9__net20 vss 22.1136e-18
c239 n39__clk100m vss 16.6506e-18
c240 n31__clk100m vss 16.6433e-18
c241 n3__i70__x vss 28.5398e-18
c242 n27__clk100m vss 16.652e-18
c243 n4__i70__x vss 25.4835e-18
c244 n19__clk100m vss 16.6632e-18
c245 n15__clk100m vss 17.8069e-18
c246 n19__net9 vss 37.7788e-18
c247 n9__clk100m vss 43.8512e-18
c248 n20__net9 vss 23.4233e-18
c249 n3__net15 vss 30.0177e-18
c250 n4__net15 vss 24.6439e-18
c251 n10__net9 vss 24.4354e-18
c252 n9__net9 vss 23.0168e-18
c253 n5__net9 vss 21.5467e-18
c254 n6__net9 vss 27.1742e-18
c255 n8__clk1pt6g vss 37.962e-18
c256 n9__clk1pt6g vss 22.1142e-18
c257 n3__i69__x vss 28.5398e-18
c258 n4__i69__x vss 25.4816e-18
c259 n1__clk1pt6g_b vss 37.7838e-18
c260 n2__clk1pt6g_b vss 23.3768e-18
c261 n3__net1 vss 29.9516e-18
c262 n4__net1 vss 24.5755e-18
c263 n9__net6 vss 26.7783e-18
c264 n13__net6 vss 86.6031e-18
c265 n41__clk1pt6g vss 75.3506e-18
c266 n37__clk1pt6g_b vss 79.3342e-18
c267 n24__net13 vss 23.4378e-18
c268 n28__net13 vss 76.9656e-18
c269 n11__net11 vss 71.494e-18
c270 n35__clk1pt6g vss 24.4477e-18
c271 n5__i51__x vss 61.7453e-18
c272 n36__clk1pt6g_b vss 77.1388e-18
c273 n30__clk1pt6g vss 71.1184e-18
c274 n5__net11 vss 76.3628e-18
c275 n22__net13 vss 79.8299e-18
c276 n30__clk1pt6g_b vss 27.9202e-18
c277 n7__net7 vss 42.4913e-18
c278 n5__net5 vss 50.6213e-18
c279 n29__clk1pt6g vss 76.5377e-18
c280 n25__clk1pt6g_b vss 78.8328e-18
c281 n23__clk1pt6g vss 24.253e-18
c282 n7__net13 vss 87.0152e-18
c283 n24__clk1pt6g_b vss 76.1107e-18
c284 n18__clk1pt6g vss 70.0845e-18
c285 n24__net12 vss 25.0748e-18
c286 n28__net12 vss 76.8414e-18
c287 n11__net26 vss 71.494e-18
c288 n18__clk1pt6g_b vss 22.1373e-18
c289 n12__net8 vss 76.9914e-18
c290 n5__i72__x vss 61.6776e-18
c291 n2__net7 vss 19.0351e-18
c292 n5__net26 vss 76.5084e-18
c293 n22__net12 vss 79.8434e-18
c294 n5__net19 vss 50.7436e-18
c295 n5__i50__net1 vss 51.1073e-18
c296 n2__i50__net1 vss 30.3596e-18
c297 n7__net12 vss 87.1764e-18
c298 n29__net3 vss 24.0724e-18
c299 n26__net3 vss 92.7776e-18
c300 n11__net23 vss 71.4776e-18
c301 n5__i71__x vss 61.9704e-18
c302 n5__net23 vss 76.413e-18
c303 n22__net3 vss 79.8306e-18
c304 n5__net17 vss 50.8244e-18
c305 n7__net3 vss 87.1297e-18
c306 n1__clk100m vss 58.0052e-18
c307 n24__net9 vss 31.6508e-18
c308 n28__net9 vss 76.9109e-18
c309 n11__net20 vss 71.5237e-18
c310 n5__i70__x vss 61.8263e-18
c311 n5__net20 vss 76.6498e-18
c312 n22__net9 vss 79.8545e-18
c313 n5__net15 vss 47.6349e-18
c314 n7__net9 vss 86.9938e-18
c315 n6__clk1pt6g_b vss 20.9874e-18
c316 n10__clk1pt6g_b vss 77.102e-18
c317 n11__clk1pt6g vss 71.7137e-18
c318 n5__i69__x vss 61.929e-18
c319 n1__clk1pt6g vss 20.6828e-18
c320 n5__clk1pt6g vss 76.5486e-18
c321 n4__clk1pt6g_b vss 79.8505e-18
c322 n5__net1 vss 41.0802e-18
c323 n51__clk1pt6g vss 61.0916e-18
c324 n51__clk1pt6g_b vss 117.193e-18
c325 n50__clk1pt6g vss 7.53833e-18
c326 n44__clk1pt6g_b vss 49.3299e-18
c327 n17__clk1pt6g_b vss 510.837e-18
c328 n16__clk1pt6g vss 652.552e-18
c329 n23__net6 vss 59.8917e-18
c330 n24__net6 vss 74.6334e-18
c331 n15__net5 vss 100.078e-18
c332 n39__net13 vss 116.479e-18
c333 n50__clk1pt6g_b vss 6.6497e-18
c334 n31__net7 vss 124.612e-18
c335 n14__net5 vss 110.691e-18
c336 n48__clk1pt6g vss 6.63419e-18
c337 n15__net19 vss 114.645e-18
c338 n38__net13 vss 122.41e-18
c339 n39__net12 vss 179.539e-18
c340 n43__clk1pt6g_b vss 11.9975e-18
c341 n26__net7 vss 113.003e-18
c342 n10__net19 vss 110.53e-18
c343 n15__net17 vss 114.809e-18
c344 n35__net12 vss 118.887e-18
c345 n39__net3 vss 146.95e-18
c346 n10__net17 vss 110.754e-18
c347 n15__net15 vss 114.823e-18
c348 n35__net3 vss 113.537e-18
c349 n39__net9 vss 161.64e-18
c350 n10__net15 vss 118.835e-18
c351 n15__net1 vss 116.774e-18
c352 n35__net9 vss 183.169e-18
c353 n15__clk1pt6g vss 10.1169e-18
c354 n10__net1 vss 96.0646e-18
c355 n22__net6 vss 86.2814e-18
c356 n21__net6 vss 52.3999e-18
c357 n14__vdd vss 62.8857e-18
c358 n60__vdd vss 75.7365e-18
c359 n10__net5 vss 44.1579e-18
c360 n6__i52__net3 vss 91.8501e-18
c361 n6__i51__net5 vss 67.0727e-18
c362 n47__clk1pt6g vss 282.627e-18
c363 n49__clk1pt6g_b vss 196.112e-18
c364 n6__i52__net2 vss 152.543e-18
c365 n4__i52__net3 vss 110.147e-18
c366 n37__net13 vss 100.771e-18
c367 n7__i51__net4 vss 97.6236e-18
c368 n4__i51__net5 vss 75.4423e-18
c369 n46__clk1pt6g vss 49.3783e-18
c370 n36__net13 vss 208.104e-18
c371 n19__net11 vss 309.52e-18
c372 n2__i52__net3 vss 104.866e-18
c373 n2__i52__net2 vss 50.9609e-18
c374 n2__i51__net4 vss 83.6011e-18
c375 n2__i51__net5 vss 95.4687e-18
c376 n6__i52__net5 vss 95.4417e-18
c377 n6__i51__net3 vss 104.656e-18
c378 n48__clk1pt6g_b vss 200.292e-18
c379 n45__clk1pt6g vss 303.921e-18
c380 n7__i52__net4 vss 92.2726e-18
c381 n4__i52__net5 vss 81.7278e-18
c382 n18__net11 vss 184.985e-18
c383 n6__i51__net2 vss 163.144e-18
c384 n4__i51__net3 vss 107.222e-18
c385 n47__clk1pt6g_b vss 49.4898e-18
c386 n17__net11 vss 296.872e-18
c387 n35__net13 vss 207.621e-18
c388 n2__i52__net4 vss 84.7212e-18
c389 n2__i52__net5 vss 83.6895e-18
c390 n29__net7 vss 76.5971e-18
c391 n2__i51__net2 vss 146.838e-18
c392 n2__i51__net3 vss 89.5154e-18
c393 n6__i53__net3 vss 96.3408e-18
c394 n9__net5 vss 71.1109e-18
c395 n44__clk1pt6g vss 290.356e-18
c396 n46__clk1pt6g_b vss 204.964e-18
c397 n13__net11 vss 97.4317e-18
c398 n6__i53__net2 vss 161.01e-18
c399 n4__i53__net3 vss 111.769e-18
c400 n43__clk1pt6g vss 50.5925e-18
c401 n2__i53__net3 vss 105.754e-18
c402 n2__i53__net2 vss 51.0461e-18
c403 n11__net19 vss 15.5961e-18
c404 n34__net13 vss 98.787e-18
c405 n6__i53__net5 vss 96.2963e-18
c406 n45__clk1pt6g_b vss 200.809e-18
c407 n42__clk1pt6g vss 313.219e-18
c408 n6__i72__net5 vss 67.0932e-18
c409 n7__i53__net4 vss 96.2492e-18
c410 n4__i53__net5 vss 73.1813e-18
c411 n38__net12 vss 77.7653e-18
c412 n42__clk1pt6g_b vss 62.5715e-18
c413 n7__i72__net4 vss 98.4132e-18
c414 n4__i72__net5 vss 75.4405e-18
c415 n2__i53__net4 vss 80.2833e-18
c416 n2__i53__net5 vss 71.1289e-18
c417 n37__net12 vss 208.134e-18
c418 n19__net26 vss 309.656e-18
c419 n2__i72__net4 vss 83.3469e-18
c420 n2__i72__net5 vss 95.4661e-18
c421 n9__i50__net1 vss 141.822e-18
c422 n14__i50__net1 vss 202.153e-18
c423 n25__net7 vss 69.5887e-18
c424 n6__i72__net3 vss 104.63e-18
c425 n24__net7 vss 154.54e-18
c426 n6__i72__net2 vss 163.4e-18
c427 n4__i72__net3 vss 107.222e-18
c428 n17__net26 vss 296.915e-18
c429 n36__net12 vss 207.704e-18
c430 n2__i72__net2 vss 147.08e-18
c431 n2__i72__net3 vss 89.5116e-18
c432 n8__i50__net1 vss 98.2283e-18
c433 n16__net2 vss 71.3322e-18
c434 n18__net2 vss 69.8416e-18
c435 n9__net19 vss 71.1661e-18
c436 n21__net7 vss 130.997e-18
c437 n13__net26 vss 116.188e-18
c438 n12__net2 vss 69.8123e-18
c439 n14__net2 vss 61.0188e-18
c440 n7__i50__net1 vss 293.178e-18
c441 n11__net17 vss 15.5594e-18
c442 n34__net12 vss 110.868e-18
c443 n10__net2 vss 101.862e-18
c444 n6__i71__net5 vss 67.0932e-18
c445 n38__net3 vss 109.469e-18
c446 n7__i71__net4 vss 97.9933e-18
c447 n4__i71__net5 vss 75.4433e-18
c448 n37__net3 vss 208.134e-18
c449 n19__net23 vss 309.57e-18
c450 n2__i71__net4 vss 83.4218e-18
c451 n2__i71__net5 vss 95.4687e-18
c452 n6__i71__net3 vss 104.656e-18
c453 n18__net23 vss 193.414e-18
c454 n6__i71__net2 vss 165.232e-18
c455 n4__i71__net3 vss 107.222e-18
c456 n17__net23 vss 296.736e-18
c457 n36__net3 vss 207.623e-18
c458 n2__i71__net2 vss 147.522e-18
c459 n2__i71__net3 vss 89.5211e-18
c460 n9__net17 vss 71.2669e-18
c461 n13__net23 vss 94.3902e-18
c462 n11__net15 vss 15.6142e-18
c463 n34__net3 vss 111.962e-18
c464 n6__i70__net5 vss 67.0914e-18
c465 n38__net9 vss 111.239e-18
c466 n7__i70__net4 vss 99.9223e-18
c467 n4__i70__net5 vss 75.4405e-18
c468 n37__net9 vss 208.198e-18
c469 n19__net20 vss 309.695e-18
c470 n2__i70__net4 vss 83.5796e-18
c471 n2__i70__net5 vss 95.4664e-18
c472 n6__i70__net3 vss 104.656e-18
c473 n18__net20 vss 193.041e-18
c474 n6__i70__net2 vss 165.344e-18
c475 n4__i70__net3 vss 107.222e-18
c476 n17__net20 vss 297.126e-18
c477 n36__net9 vss 208.315e-18
c478 n2__i70__net2 vss 146.174e-18
c479 n2__i70__net3 vss 89.5235e-18
c480 n9__net15 vss 70.0079e-18
c481 n13__net20 vss 107.788e-18
c482 n11__net1 vss 15.5595e-18
c483 n34__net9 vss 81.7045e-18
c484 n6__i69__net5 vss 67.0932e-18
c485 n15__clk1pt6g_b vss 48.8493e-18
c486 n7__i69__net4 vss 98.6556e-18
c487 n4__i69__net5 vss 75.4591e-18
c488 n14__clk1pt6g_b vss 208.175e-18
c489 n17__clk1pt6g vss 309.581e-18
c490 n2__i69__net4 vss 80.432e-18
c491 n2__i69__net5 vss 95.4687e-18
c492 n6__i69__net3 vss 104.656e-18
c493 n14__clk1pt6g vss 46.5968e-18
c494 n6__i69__net2 vss 163.242e-18
c495 n4__i69__net3 vss 107.222e-18
c496 n13__clk1pt6g vss 284.507e-18
c497 n13__clk1pt6g_b vss 203.403e-18
c498 n2__i69__net2 vss 139.026e-18
c499 n2__i69__net3 vss 89.0682e-18
c500 n9__net1 vss 48.2484e-18
c501 n15__vdd vss 5.46749e-15
c502 n58__vdd vss 260.013e-18
c503 n26__vdd vss 80.4693e-18
c504 n12__net5 vss 62.1257e-18
c505 n5__i52__net3 vss 40.0001e-18
c506 n5__i51__net5 vss 37.9824e-18
c507 n19__net6 vss 70.6354e-18
c508 n3__i52__net3 vss 50.5285e-18
c509 n3__i51__net5 vss 46.809e-18
c510 n11__i52__x vss 68.9334e-18
c511 n5__i52__net5 vss 37.2567e-18
c512 n5__i51__net3 vss 35.4211e-18
c513 n10__i51__x vss 67.9228e-18
c514 n3__i52__net5 vss 46.3961e-18
c515 n3__i51__net3 vss 51.0016e-18
c516 n30__net7 vss 72.3696e-18
c517 n5__i53__net3 vss 39.4799e-18
c518 n3__i53__net3 vss 52.2391e-18
c519 n15__net11 vss 63.148e-18
c520 n11__i53__x vss 67.4163e-18
c521 n13__net19 vss 61.1592e-18
c522 n5__i53__net5 vss 37.4391e-18
c523 n5__i72__net5 vss 37.9824e-18
c524 n3__i53__net5 vss 46.7304e-18
c525 n32__net13 vss 70.6354e-18
c526 n19__net8 vss 70.2049e-18
c527 n3__i72__net5 vss 46.809e-18
c528 n12__i50__net1 vss 99.7216e-18
c529 n5__i72__net3 vss 35.4669e-18
c530 n10__i72__x vss 67.9228e-18
c531 n6__i50__net2 vss 108.913e-18
c532 n3__i72__net3 vss 51.0507e-18
c533 n7__i50__net2 vss 95.7709e-18
c534 n17__net2 vss 62.7525e-18
c535 n5__i50__net2 vss 98.3109e-18
c536 n17__net7 vss 72.0471e-18
c537 n15__net26 vss 63.148e-18
c538 n13__net2 vss 81.2834e-18
c539 n20__net7 vss 75.0443e-18
c540 n13__net17 vss 61.1592e-18
c541 n12__net4 vss 57.7118e-18
c542 n5__i71__net5 vss 37.9824e-18
c543 n32__net12 vss 70.6354e-18
c544 n3__i71__net5 vss 46.809e-18
c545 n26__net10 vss 98.9541e-18
c546 n54__net14 vss 185.465e-18
c547 n5__i71__net3 vss 35.4706e-18
c548 n10__i71__x vss 67.9234e-18
c549 n55__net14 vss 184.721e-18
c550 n3__i71__net3 vss 51.0016e-18
c551 n56__clk100m vss 186.805e-18
c552 n57__clk100m vss 187.142e-18
c553 n15__net23 vss 63.1508e-18
c554 n59__clk100m vss 184.897e-18
c555 n61__clk100m vss 188.122e-18
c556 n13__net15 vss 61.1592e-18
c557 n5__i70__net5 vss 38.0737e-18
c558 n6__clk100m_b vss 183.687e-18
c559 n32__net3 vss 70.6354e-18
c560 n3__i70__net5 vss 47.0033e-18
c561 n7__clk100m_b vss 185.963e-18
c562 n9__clk100m_b vss 184.865e-18
c563 n5__i70__net3 vss 35.4736e-18
c564 n11__clk100m_b vss 185.924e-18
c565 n10__i70__x vss 67.9234e-18
c566 n3__i70__net3 vss 51.0016e-18
c567 n13__net5 vss 104.409e-18
c568 n1__vdd vss 59.1248e-18
c569 n59__vdd vss 108.286e-18
c570 n11__i52__net2 vss 91.3785e-18
c571 n13__i51__net4 vss 61.9468e-18
c572 n16__vdd vss 118.373e-18
c573 n20__net6 vss 111.982e-18
c574 n8__i51__net4 vss 65.223e-18
c575 n9__i52__x vss 106.822e-18
c576 n61__vdd vss 116.873e-18
c577 n3__i52__net2 vss 93.8005e-18
c578 n3__i51__net4 vss 60.0661e-18
c579 n17__vdd vss 110.117e-18
c580 n62__vdd vss 107.772e-18
c581 n13__i52__net4 vss 60.5669e-18
c582 n18__vdd vss 117.321e-18
c583 n11__i51__x vss 108.564e-18
c584 n8__i52__net4 vss 65.2531e-18
c585 n27__net7 vss 125.241e-18
c586 n63__vdd vss 117.894e-18
c587 n3__i52__net4 vss 61.3494e-18
c588 n19__vdd vss 99.9734e-18
c589 n64__vdd vss 69.3194e-18
c590 n11__i53__net2 vss 90.1088e-18
c591 n20__vdd vss 117.957e-18
c592 n102__vdd vss 60.0335e-18
c593 n7__i53__net2 vss 7.85541e-18
c594 n16__net11 vss 101.145e-18
c595 n9__i53__x vss 111.95e-18
c596 n66__vdd vss 61.3244e-18
c597 n3__i53__net2 vss 94.3199e-18
c598 n103__vdd vss 58.4701e-18
c599 n21__vdd vss 109.769e-18
c600 n14__net19 vss 104.543e-18
c601 n13__i53__net4 vss 60.7505e-18
c602 n68__vdd vss 107.857e-18
c603 n22__vdd vss 117.062e-18
c604 n13__i72__net4 vss 61.7156e-18
c605 n8__i53__net4 vss 65.3207e-18
c606 n33__net13 vss 112.903e-18
c607 n17__net8 vss 121.564e-18
c608 n8__i72__net4 vss 65.4481e-18
c609 n3__i53__net4 vss 60.355e-18
c610 n69__vdd vss 116.859e-18
c611 n23__vdd vss 102.889e-18
c612 n3__i72__net4 vss 60.2055e-18
c613 n10__i50__net1 vss 113.01e-18
c614 n70__vdd vss 107.728e-18
c615 n24__vdd vss 120.001e-18
c616 n25__vdd vss 111.6e-18
c617 n11__i72__x vss 109.458e-18
c618 n13__vdd vss 183.997e-18
c619 n71__vdd vss 117.898e-18
c620 n8__i50__net2 vss 164.132e-18
c621 n15__net2 vss 141.109e-18
c622 n72__vdd vss 69.5306e-18
c623 n9__i50__net2 vss 161.515e-18
c624 n104__vdd vss 60.1364e-18
c625 n15__net7 vss 161.493e-18
c626 n16__net26 vss 101.365e-18
c627 n11__net2 vss 117.344e-18
c628 n74__vdd vss 60.6971e-18
c629 n23__net7 vss 142.484e-18
c630 n105__vdd vss 58.2297e-18
c631 n14__net17 vss 104.604e-18
c632 n140__vdd vss 95.2751e-18
c633 n76__vdd vss 107.194e-18
c634 n10__net4 vss 96.1309e-18
c635 n139__vdd vss 59.0344e-18
c636 n13__i71__net4 vss 61.7156e-18
c637 n33__net12 vss 112.181e-18
c638 n137__vdd vss 104.497e-18
c639 n8__i71__net4 vss 65.2418e-18
c640 n24__net10 vss 182.56e-18
c641 n135__vdd vss 88.4639e-18
c642 n77__vdd vss 116.876e-18
c643 n3__i71__net4 vss 60.0661e-18
c644 n133__vdd vss 187.097e-18
c645 n78__vdd vss 107.728e-18
c646 n51__net14 vss 341.833e-18
c647 n131__vdd vss 339.01e-18
c648 n11__i71__x vss 109.405e-18
c649 n56__net14 vss 340.236e-18
c650 n129__vdd vss 180.406e-18
c651 n79__vdd vss 117.905e-18
c652 n127__vdd vss 189.375e-18
c653 n51__clk100m vss 340.319e-18
c654 n80__vdd vss 69.5542e-18
c655 n125__vdd vss 338.048e-18
c656 n58__clk100m vss 342.797e-18
c657 n106__vdd vss 60.1739e-18
c658 n123__vdd vss 337.65e-18
c659 n16__net23 vss 100.24e-18
c660 n60__clk100m vss 342.814e-18
c661 n82__vdd vss 60.7508e-18
c662 n121__vdd vss 338.149e-18
c663 n107__vdd vss 58.8404e-18
c664 n62__clk100m vss 342.45e-18
c665 n14__net15 vss 104.52e-18
c666 n119__vdd vss 187.326e-18
c667 n84__vdd vss 107.094e-18
c668 n117__vdd vss 182.976e-18
c669 n13__i70__net4 vss 61.8024e-18
c670 n1__clk100m_b vss 340.319e-18
c671 n33__net3 vss 112.009e-18
c672 n115__vdd vss 338.048e-18
c673 n8__i70__net4 vss 65.2958e-18
c674 n8__clk100m_b vss 342.797e-18
c675 n85__vdd vss 116.886e-18
c676 n113__vdd vss 337.65e-18
c677 n3__i70__net4 vss 60.4164e-18
c678 n10__clk100m_b vss 342.834e-18
c679 n86__vdd vss 107.736e-18
c680 n109__vdd vss 339.59e-18
c681 n12__clk100m_b vss 341.552e-18
c682 n11__i70__x vss 109.663e-18
c683 n87__vdd vss 119.118e-18
c684 n15__net20 vss 63.1508e-18
c685 n13__net1 vss 61.1592e-18
c686 n5__i69__net5 vss 37.9824e-18
c687 n32__net9 vss 70.6354e-18
c688 n3__i69__net5 vss 46.8302e-18
c689 n5__i69__net3 vss 35.4211e-18
c690 n10__i69__x vss 67.818e-18
c691 n3__i69__net3 vss 51.0016e-18
c692 n88__vdd vss 70.7102e-18
c693 n110__vdd vss 60.3603e-18
c694 n16__net20 vss 101.703e-18
c695 n95__vdd vss 60.9088e-18
c696 n111__vdd vss 60.1075e-18
c697 n14__net1 vss 105.429e-18
c698 n97__vdd vss 107.649e-18
c699 n13__i69__net4 vss 61.7156e-18
c700 n33__net9 vss 112.796e-18
c701 n8__i69__net4 vss 65.7755e-18
c702 n98__vdd vss 117.699e-18
c703 n3__i69__net4 vss 60.2299e-18
c704 n99__vdd vss 108.126e-18
c705 n11__i69__x vss 108.676e-18
c706 n100__vdd vss 118.784e-18
c707 n101__vdd vss 59.9858e-18
c708 n8__net1 vss 17.937e-18
c709 n2__clk1pt6g vss 25.4838e-18
c710 n4__clk1pt6g vss 17.6903e-18
c711 n3__clk1pt6g_b vss 17.3202e-18
c712 n8__i69__x vss 18.271e-18
c713 n7__clk1pt6g_b vss 22.719e-18
c714 n9__clk1pt6g_b vss 18.3889e-18
c715 n10__clk1pt6g vss 15.1063e-18
c716 n14__net9 vss 27.4477e-18
c717 n15__net9 vss 23.9276e-18
c718 n8__net9 vss 22.8961e-18
c719 n11__net9 vss 8.36539e-18
c720 n8__net15 vss 17.8233e-18
c721 n2__net20 vss 30.9519e-18
c722 n4__net20 vss 18.3654e-18
c723 n21__net9 vss 17.5917e-18
c724 n8__i70__x vss 18.1642e-18
c725 n25__net9 vss 27.526e-18
c726 n27__net9 vss 18.2424e-18
c727 n10__net20 vss 15.102e-18
c728 n50__clk100m vss 3.98276e-18
c729 n48__clk100m vss 2.75678e-18
c730 n3__clk100m vss 21.4409e-18
c731 n4__clk100m vss 20.4599e-18
c732 n5__clk100m vss 15.5895e-18
c733 n6__clk100m vss 16.6739e-18
c734 n7__clk100m vss 15.5249e-18
c735 n8__clk100m vss 17.8001e-18
c736 n10__clk100m vss 13.0204e-18
c737 n12__clk100m vss 21.5499e-18
c738 n14__clk100m vss 9.61739e-18
c739 n18__clk100m vss 12.5858e-18
c740 n22__clk100m vss 10.6407e-18
c741 n24__clk100m vss 19.7081e-18
c742 n26__clk100m vss 9.60846e-18
c743 n30__clk100m vss 12.5742e-18
c744 n34__clk100m vss 10.6391e-18
c745 n36__clk100m vss 19.7081e-18
c746 n38__clk100m vss 9.63379e-18
c747 n42__clk100m vss 9.61418e-18
c748 n46__clk100m vss 12.4578e-18
c749 n9__i69__x vss 74.9505e-18
c750 n14__net3 vss 26.3695e-18
c751 n15__net3 vss 23.1045e-18
c752 n8__net3 vss 21.9977e-18
c753 n11__net3 vss 8.36539e-18
c754 n31__net9 vss 66.8476e-18
c755 n12__net1 vss 29.5552e-18
c756 n8__net17 vss 17.8317e-18
c757 n50__net14 vss 3.98276e-18
c758 n48__net14 vss 2.75853e-18
c759 n3__net14 vss 17.5259e-18
c760 n4__net14 vss 15.3599e-18
c761 n5__net14 vss 16.1101e-18
c762 n6__net14 vss 15.8449e-18
c763 n7__net14 vss 16.6712e-18
c764 n8__net14 vss 22.5004e-18
c765 n10__net14 vss 15.4501e-18
c766 n12__net14 vss 21.5276e-18
c767 n14__net14 vss 9.61459e-18
c768 n18__net14 vss 12.579e-18
c769 n22__net14 vss 10.6391e-18
c770 n24__net14 vss 19.7081e-18
c771 n26__net14 vss 9.60376e-18
c772 n30__net14 vss 12.6719e-18
c773 n34__net14 vss 10.6391e-18
c774 n36__net14 vss 19.7081e-18
c775 n38__net14 vss 9.63466e-18
c776 n42__net14 vss 9.61505e-18
c777 n46__net14 vss 12.4578e-18
c778 n14__net20 vss 11.6079e-18
c779 n2__net23 vss 30.9871e-18
c780 n4__net23 vss 18.3654e-18
c781 n21__net3 vss 17.5917e-18
c782 n21__net10 vss 2.73246e-18
c783 n2__net10 vss 19.7396e-18
c784 n4__net10 vss 16.8874e-18
c785 n5__net10 vss 18.9324e-18
c786 n7__net10 vss 15.418e-18
c787 n9__net10 vss 21.5276e-18
c788 n11__net10 vss 9.6194e-18
c789 n15__net10 vss 9.59202e-18
c790 n19__net10 vss 12.4769e-18
c791 n8__i71__x vss 18.1703e-18
c792 n9__net4 vss 3.45854e-18
c793 n2__net4 vss 5.45548e-18
c794 n5__net4 vss 12.4732e-18
c795 n28__net3 vss 13.3734e-18
c796 n10__net23 vss 14.6945e-18
c797 n9__i70__x vss 74.5885e-18
c798 n9__net2 vss 5.784e-18
c799 n2__net2 vss 5.76287e-18
c800 n5__net2 vss 12.1615e-18
c801 n2__clk100m_b vss 45.2839e-18
c802 n3__clk100m_b vss 43.1592e-18
c803 n4__clk100m_b vss 43.2056e-18
c804 n5__clk100m_b vss 30.9706e-18
c805 n14__net12 vss 25.5986e-18
c806 n15__net12 vss 23.9556e-18
c807 n8__net12 vss 23.3169e-18
c808 n11__net12 vss 8.33722e-18
c809 n31__net3 vss 66.9455e-18
c810 n12__net15 vss 29.4664e-18
c811 n8__net19 vss 17.8307e-18
c812 n14__net23 vss 11.4664e-18
c813 n3__net7 vss 16.0771e-18
c814 n2__net26 vss 30.474e-18
c815 n4__net26 vss 18.2295e-18
c816 n21__net12 vss 17.5912e-18
c817 n52__clk100m vss 45.3478e-18
c818 n53__clk100m vss 43.1642e-18
c819 n54__clk100m vss 43.1612e-18
c820 n55__clk100m vss 32.0539e-18
c821 n2__net8 vss 69.4873e-18
c822 n3__net8 vss 97.3394e-18
c823 n5__net8 vss 18.9633e-18
c824 n7__net8 vss 114.258e-18
c825 n8__net8 vss 141.365e-18
c826 n8__i72__x vss 18.1642e-18
c827 n25__net12 vss 26.2269e-18
c828 n27__net12 vss 18.2424e-18
c829 n10__net26 vss 15.102e-18
c830 n19__clk1pt6g_b vss 27.9059e-18
c831 n21__clk1pt6g_b vss 19.1173e-18
c832 n22__clk1pt6g vss 18.6876e-18
c833 n19__clk1pt6g vss 8.45842e-18
c834 n52__net14 vss 42.8502e-18
c835 n53__net14 vss 54.1887e-18
c836 n9__i71__x vss 74.749e-18
c837 n7__i53__x vss 7.28156e-18
c838 n8__i53__x vss 3.71415e-18
c839 n4__i53__x vss 14.6548e-18
c840 n25__net10 vss 50.1342e-18
c841 n24__clk1pt6g vss 31.8356e-18
c842 n26__clk1pt6g vss 18.3164e-18
c843 n29__clk1pt6g_b vss 20.7812e-18
c844 n26__clk1pt6g_b vss 9.68098e-18
c845 n14__net13 vss 27.4836e-18
c846 n15__net13 vss 24.0514e-18
c847 n8__net13 vss 22.8015e-18
c848 n11__net13 vss 8.33722e-18
c849 n11__net4 vss 54.3043e-18
c850 n31__net12 vss 66.698e-18
c851 n12__net17 vss 29.465e-18
c852 n13__net7 vss 7.0645e-18
c853 n14__net7 vss 3.90214e-18
c854 n10__net7 vss 13.6741e-18
c855 n8__net5 vss 17.8322e-18
c856 n31__clk1pt6g_b vss 31.9187e-18
c857 n33__clk1pt6g_b vss 18.9841e-18
c858 n34__clk1pt6g vss 20.7762e-18
c859 n31__clk1pt6g vss 8.89995e-18
c860 n14__net26 vss 11.4439e-18
c861 n16__net7 vss 53.8921e-18
c862 n19__net7 vss 37.0865e-18
c863 n2__net11 vss 29.4268e-18
c864 n4__net11 vss 18.1956e-18
c865 n21__net13 vss 17.5912e-18
c866 n19__net2 vss 33.2425e-18
c867 n20__net2 vss 59.3845e-18
c868 n7__i52__x vss 7.0984e-18
c869 n8__i52__x vss 3.72573e-18
c870 n4__i52__x vss 14.519e-18
c871 n8__i51__x vss 18.1626e-18
c872 n2__i50__net2 vss 56.8714e-18
c873 n3__i50__net2 vss 46.4331e-18
c874 n4__i50__net2 vss 41.3514e-18
c875 n36__clk1pt6g vss 31.4989e-18
c876 n38__clk1pt6g vss 18.2032e-18
c877 n41__clk1pt6g_b vss 20.9186e-18
c878 n38__clk1pt6g_b vss 9.9997e-18
c879 n25__net13 vss 30.522e-18
c880 n27__net13 vss 18.239e-18
c881 n10__net11 vss 15.0985e-18
c882 n9__i72__x vss 74.4474e-18
c883 n7__net6 vss 4.21112e-18
c884 n8__net6 vss 4.34309e-18
c885 n4__net6 vss 13.581e-18
c886 n17__net6 vss 19.5099e-18
c887 n18__net8 vss 67.9238e-18
c888 n31__net13 vss 66.7017e-18
c889 n12__net19 vss 29.4675e-18
c890 n10__i53__x vss 69.2262e-18
c891 n14__net11 vss 11.444e-18
c892 n28__net7 vss 40.3986e-18
c893 n9__i51__x vss 74.3634e-18
c894 n10__i52__x vss 68.5673e-18
c895 n18__net6 vss 66.8261e-18
c896 n11__net5 vss 30.9764e-18
c897 n2__vdd vss 15.6023e-18
c898 n3__vdd vss 44.3044e-18
c899 n4__vdd vss 68.7321e-18
c900 n5__vdd vss 43.5226e-18
c901 n6__vdd vss 69.7439e-18
c902 n7__vdd vss 46.2656e-18
c903 n8__vdd vss 68.8693e-18
c904 n9__vdd vss 46.0805e-18
c905 n10__vdd vss 104.373e-18
c906 n11__vdd vss 41.311e-18
c907 n12__vdd vss 33.6725e-18
c908 n27__vdd vss 30.4216e-18
c909 n28__vdd vss 41.4691e-18
c910 n29__vdd vss 122.463e-18
c911 n30__vdd vss 65.0904e-18
c912 n31__vdd vss 108.427e-18
c913 n32__vdd vss 38.578e-18
c914 n33__vdd vss 32.0662e-18
c915 n34__vdd vss 100.938e-18
c916 n35__vdd vss 125.481e-18
c917 n36__vdd vss 84.0889e-18
c918 n37__vdd vss 111.189e-18
c919 n38__vdd vss 52.293e-18
c920 n39__vdd vss 51.3265e-18
c921 n40__vdd vss 107.722e-18
c922 n41__vdd vss 127.432e-18
c923 n42__vdd vss 73.6516e-18
c924 n43__vdd vss 112.165e-18
c925 n44__vdd vss 44.0927e-18
c926 n45__vdd vss 38.9316e-18
c927 n46__vdd vss 107.519e-18
c928 n47__vdd vss 127.813e-18
c929 n48__vdd vss 74.2621e-18
c930 n49__vdd vss 108.596e-18
c931 n50__vdd vss 22.1263e-18
c932 n51__vdd vss 59.7611e-18
c933 n52__vdd vss 14.6021e-18
c934 n53__vdd vss 80.2414e-18
c935 n54__vdd vss 80.3451e-18
c936 n55__vdd vss 49.2504e-18
c937 n56__vdd vss 63.225e-18
c938 n57__vdd vss 18.3264e-18
c939 n65__vdd vss 30.6941e-18
c940 n67__vdd vss 28.5335e-18
c941 n73__vdd vss 30.5952e-18
c942 n75__vdd vss 27.8382e-18
c943 n81__vdd vss 31.8933e-18
c944 n83__vdd vss 28.0287e-18
c945 n89__vdd vss 15.3239e-18
c946 n92__vdd vss 27.894e-18
c947 n94__vdd vss 29.118e-18
c948 n96__vdd vss 28.1413e-18
c949 n108__vdd vss 30.3336e-18
c950 n112__vdd vss 30.3242e-18
c951 n114__vdd vss 30.3414e-18
c952 n116__vdd vss 14.4311e-18
c953 n118__vdd vss 14.229e-18
c954 n120__vdd vss 30.3414e-18
c955 n122__vdd vss 30.3242e-18
c956 n124__vdd vss 30.3414e-18
c957 n126__vdd vss 14.4311e-18
c958 n128__vdd vss 14.229e-18
c959 n130__vdd vss 30.3417e-18
c960 n132__vdd vss 16.6984e-18
c961 n134__vdd vss 33.797e-18
c962 n136__vdd vss 15.3211e-18
c963 n138__vdd vss 21.8591e-18
c964 n52__clk1pt6g_b vss 520.196e-18
c965 n52__clk1pt6g vss 472.873e-18
rh1 n51__clk1pt6g_b n52__clk1pt6g_b 2.0695
rh2 n52__clk1pt6g_b n17__clk1pt6g_b 5.4849
rh3 n52__clk1pt6g_b n44__clk1pt6g_b 866.5e-3
rh4 n51__clk1pt6g n52__clk1pt6g 1.3351
rh5 n52__clk1pt6g n16__clk1pt6g 7.6603
rh6 n52__clk1pt6g n50__clk1pt6g 139.3e-3
ri1 n15__clk1pt6g n16__clk1pt6g 500e-3
ri2 n17__clk1pt6g_b n16__clk1pt6g_b 500e-3
ri3 n15__net1 n10__net1 1.4158
ri4 n39__net9 n35__net9 1.506
ri5 n15__net15 n10__net15 1.365
ri6 n39__net3 n35__net3 1.4472
ri7 n15__net17 n10__net17 1.365
ri8 n43__clk1pt6g_b n44__clk1pt6g_b 500e-3
ri9 n39__net12 n35__net12 1.4472
ri10 n15__net19 n10__net19 1.365
ri11 n48__clk1pt6g n50__clk1pt6g 500e-3
ri12 n31__net7 n26__net7 1.4933
ri13 n50__clk1pt6g_b n51__clk1pt6g_b 500e-3
ri14 n51__clk1pt6g n49__clk1pt6g 500e-3
ri15 n39__net13 n38__net13 1.4496
ri16 n15__net5 n14__net5 1.365
ri17 n23__net6 n24__net6 896.3e-3
rj1 n9__net1 n10__net1 500e-3
rj2 n14__clk1pt6g n15__clk1pt6g 500e-3
rj3 n6__i69__net3 n4__i69__net3 220.1e-3
rj4 n4__i69__net3 n2__i69__net3 217.4e-3
rj5 i69__net2 n13__i69__net2 702.9e-3
rj6 n13__i69__net2 n2__i69__net2 693.3e-3
rj7 n6__i69__net2 n13__i69__net2 500e-3
rj8 n13__clk1pt6g n17__clk1pt6g 1.1165
rj9 n14__clk1pt6g_b n13__clk1pt6g_b 704.2e-3
rj10 n15__clk1pt6g_b n16__clk1pt6g_b 500e-3
rj11 i69__net4 n16__i69__net4 698.1e-3
rj12 n16__i69__net4 n2__i69__net4 695.7e-3
rj13 n7__i69__net4 n16__i69__net4 500e-3
rj14 n6__i69__net5 n4__i69__net5 198.1e-3
rj15 n4__i69__net5 n2__i69__net5 208.8e-3
rj16 n34__net9 n35__net9 500e-3
rj17 n15__net1 n11__net1 500e-3
rj18 n9__net15 n10__net15 500e-3
rj19 n18__net20 n13__net20 994.4e-3
rj20 n6__i70__net3 n4__i70__net3 220.1e-3
rj21 n4__i70__net3 n2__i70__net3 217.4e-3
rj22 i70__net2 n13__i70__net2 702.9e-3
rj23 n13__i70__net2 n2__i70__net2 693.3e-3
rj24 n6__i70__net2 n13__i70__net2 500e-3
rj25 n17__net20 n19__net20 1.1175
rj26 n37__net9 n36__net9 704.2e-3
rj27 n38__net9 n39__net9 500e-3
rj28 i70__net4 n16__i70__net4 698.1e-3
rj29 n16__i70__net4 n2__i70__net4 695.7e-3
rj30 n7__i70__net4 n16__i70__net4 500e-3
rj31 n6__i70__net5 n4__i70__net5 198.1e-3
rj32 n4__i70__net5 n2__i70__net5 208.8e-3
rj33 n34__net3 n35__net3 500e-3
rj34 n15__net15 n11__net15 500e-3
rj35 n9__net17 n10__net17 1
rj36 n18__net23 n13__net23 994.4e-3
rj37 n6__i71__net3 n4__i71__net3 220.1e-3
rj38 n4__i71__net3 n2__i71__net3 217.4e-3
rj39 i71__net2 n13__i71__net2 702.9e-3
rj40 n13__i71__net2 n2__i71__net2 693.3e-3
rj41 n6__i71__net2 n13__i71__net2 500e-3
rj42 n17__net23 n19__net23 1.6175
rj43 n37__net3 n36__net3 1.2042
rj44 n38__net3 n39__net3 500e-3
rj45 i71__net4 n16__i71__net4 698.1e-3
rj46 n16__i71__net4 n2__i71__net4 695.7e-3
rj47 n7__i71__net4 n16__i71__net4 500e-3
rj48 n6__i71__net5 n4__i71__net5 198.1e-3
rj49 n4__i71__net5 n2__i71__net5 208.8e-3
rj50 n34__net12 n35__net12 500e-3
rj51 n15__net17 n11__net17 500e-3
rj52 n9__net19 n10__net19 500e-3
rj53 n16__net2 n19__net2 109.3e-3
rj54 n19__net2 n20__net2 284.8e-3
rj55 n20__net2 n10__net2 449.2e-3
rj56 n19__net2 n18__net2 87.54e-3
rj57 n20__net2 n14__net2 82.64e-3
rj58 n20__net2 n12__net2 104.4e-3
rj59 net26 n13__net26 1.573
rj60 n24__net7 n21__net7 1.781
rj61 n6__i72__net3 n4__i72__net3 220.1e-3
rj62 n4__i72__net3 n2__i72__net3 217.4e-3
rj63 i72__net2 n13__i72__net2 702.9e-3
rj64 n13__i72__net2 n2__i72__net2 693.3e-3
rj65 n6__i72__net2 n13__i72__net2 500e-3
rj66 n25__net7 n26__net7 500e-3
rj67 n9__i50__net1 n8__i50__net1 674.1e-3
rj68 n14__i50__net1 n7__i50__net1 1.0694
rj69 n17__net26 n19__net26 1.6175
rj70 n37__net12 n36__net12 1.2042
rj71 n42__clk1pt6g_b n43__clk1pt6g_b 500e-3
rj72 n39__net12 n38__net12 500e-3
rj73 i72__net4 n16__i72__net4 698.1e-3
rj74 n16__i72__net4 n2__i72__net4 695.7e-3
rj75 n7__i72__net4 n16__i72__net4 500e-3
rj76 n6__i72__net5 n4__i72__net5 198.1e-3
rj77 n4__i72__net5 n2__i72__net5 208.8e-3
rj78 i53__net4 n16__i53__net4 695.7e-3
rj79 n16__i53__net4 n2__i53__net4 698.1e-3
rj80 n7__i53__net4 n16__i53__net4 500e-3
rj81 n6__i53__net5 n4__i53__net5 208.8e-3
rj82 n4__i53__net5 n2__i53__net5 198.1e-3
rj83 n34__net13 n38__net13 500e-3
rj84 n15__net19 n11__net19 500e-3
rj85 n43__clk1pt6g n48__clk1pt6g 500e-3
rj86 n46__clk1pt6g_b n45__clk1pt6g_b 704e-3
rj87 n44__clk1pt6g n42__clk1pt6g 1.1165
rj88 i53__net2 n13__i53__net2 693.3e-3
rj89 n13__i53__net2 n2__i53__net2 702.9e-3
rj90 n6__i53__net2 n13__i53__net2 500e-3
rj91 n6__i53__net3 n4__i53__net3 217.4e-3
rj92 n4__i53__net3 n2__i53__net3 220.1e-3
rj93 n9__net5 n14__net5 500e-3
rj94 n29__net7 n31__net7 1
rj95 n47__clk1pt6g_b n50__clk1pt6g_b 500e-3
rj96 n18__net11 n13__net11 999.3e-3
rj97 n6__i51__net3 n4__i51__net3 220.1e-3
rj98 n4__i51__net3 n2__i51__net3 217.4e-3
rj99 i51__net2 n13__i51__net2 702.9e-3
rj100 n13__i51__net2 n2__i51__net2 693.3e-3
rj101 n6__i51__net2 n13__i51__net2 500e-3
rj102 i52__net4 n16__i52__net4 695.7e-3
rj103 n16__i52__net4 n2__i52__net4 698.1e-3
rj104 n7__i52__net4 n16__i52__net4 500e-3
rj105 n6__i52__net5 n4__i52__net5 208.8e-3
rj106 n4__i52__net5 n2__i52__net5 198.1e-3
rj107 n17__net11 n19__net11 1.1175
rj108 n36__net13 n35__net13 704.2e-3
rj109 n46__clk1pt6g n49__clk1pt6g 500e-3
rj110 n37__net13 n39__net13 500e-3
rj111 n49__clk1pt6g_b n48__clk1pt6g_b 704e-3
rj112 i51__net4 n16__i51__net4 698.1e-3
rj113 n16__i51__net4 n2__i51__net4 695.7e-3
rj114 n7__i51__net4 n16__i51__net4 500e-3
rj115 n6__i51__net5 n4__i51__net5 198.1e-3
rj116 n4__i51__net5 n2__i51__net5 208.8e-3
rj117 n47__clk1pt6g n45__clk1pt6g 1.1165
rj118 i52__net2 n13__i52__net2 693.3e-3
rj119 n13__i52__net2 n2__i52__net2 702.9e-3
rj120 n6__i52__net2 n13__i52__net2 500e-3
rj121 n6__i52__net3 n4__i52__net3 217.4e-3
rj122 n4__i52__net3 n2__i52__net3 220.1e-3
rj123 n10__net5 n15__net5 500e-3
rj124 n14__vdd n60__vdd 1.2151
rj125 n23__net6 n22__net6 500e-3
rj126 n21__net6 n24__net6 500e-3
rk1 n5__net1 n9__net1 45.6675
rk2 i69__net3 n2__i69__net3 38.0375
rk4 n2__i69__net2 n4__i69__net2 42.9e-3
rk5 n3__i69__net2 n4__i69__net2 15.5
rk7 n6__i69__net2 n8__i69__net2 28.6e-3
rk8 n7__i69__net2 n8__i69__net2 15.5
rk9 n3__i69__net3 n4__i69__net3 38.0409
rk10 n5__clk1pt6g n13__clk1pt6g 676.7e-3
rk11 n4__clk1pt6g_b n13__clk1pt6g_b 675e-3
rk12 n1__clk1pt6g n14__clk1pt6g 500e-3
rk13 n5__i69__net3 n6__i69__net3 38.057
rk15 i69__net2 n12__i69__net2 42.9e-3
rk16 n11__i69__net2 n12__i69__net2 15.5
rk17 n5__i69__x n9__i69__x 45.3061
rk18 n9__i69__x n10__i69__x 37.738
rk19 n9__i69__x n11__i69__x 15.8221
rk23 n3__i69__net4 n2__i69__net4 15.5
rk24 i69__net5 n2__i69__net5 38.039
rk28 n8__i69__net4 n7__i69__net4 15.5
rk29 n3__i69__net5 n4__i69__net5 38.0409
rk30 n10__clk1pt6g_b n14__clk1pt6g_b 676.7e-3
rk31 n11__clk1pt6g n17__clk1pt6g 675e-3
rk32 n6__clk1pt6g_b n15__clk1pt6g_b 500e-3
rk33 n5__i69__net5 n6__i69__net5 38.0428
rk37 n13__i69__net4 i69__net4 15.5
rk38 n7__net9 n31__net9 45.3153
rk39 n31__net9 n32__net9 37.738
rk40 n31__net9 n33__net9 15.8221
rk41 n11__net1 n12__net1 529.7e-3
rk42 n12__net1 n13__net1 37.6786
rk43 n12__net1 n14__net1 15.7821
rk44 net9 n34__net9 500e-3
rk45 n13__net20 n14__net20 538.5e-3
rk46 n14__net20 n15__net20 37.6818
rk47 n14__net20 n16__net20 15.7788
rk48 n5__net15 n9__net15 45.5611
rk49 i70__net3 n2__i70__net3 38.0375
rk51 n2__i70__net2 n4__i70__net2 42.9e-3
rk52 n3__i70__net2 n4__i70__net2 15.5
rk54 n6__i70__net2 n8__i70__net2 28.6e-3
rk55 n7__i70__net2 n8__i70__net2 15.5
rk56 n3__i70__net3 n4__i70__net3 38.0409
rk57 n5__net20 n17__net20 676.7e-3
rk58 n22__net9 n36__net9 675e-3
rk59 net20 n18__net20 500e-3
rk60 n5__i70__net3 n6__i70__net3 38.057
rk62 i70__net2 n12__i70__net2 42.9e-3
rk63 n11__i70__net2 n12__i70__net2 15.5
rk64 n5__i70__x n9__i70__x 45.3061
rk65 n9__i70__x n10__i70__x 37.738
rk66 n9__i70__x n11__i70__x 15.8221
rk70 n3__i70__net4 n2__i70__net4 15.5
rk71 i70__net5 n2__i70__net5 38.039
rk75 n8__i70__net4 n7__i70__net4 15.5
rk76 n3__i70__net5 n4__i70__net5 38.0409
rk77 n28__net9 n37__net9 676.7e-3
rk78 n11__net20 n19__net20 675e-3
rk79 n24__net9 n38__net9 500e-3
rk80 n1__clk100m_b n2__clk100m_b 4.733
rk81 n2__clk100m_b n3__clk100m_b 263.3e-3
rk82 n3__clk100m_b n4__clk100m_b 282.8e-3
rk83 n4__clk100m_b n5__clk100m_b 282.8e-3
rk84 n5__clk100m_b clk100m_b 169.1e-3
rk85 n2__clk100m_b n6__clk100m_b 9.8448
rk86 n3__clk100m_b n7__clk100m_b 9.8382
rk87 n3__clk100m_b n8__clk100m_b 4.7264
rk88 n4__clk100m_b n9__clk100m_b 9.8382
rk89 n4__clk100m_b n10__clk100m_b 4.7264
rk90 n5__clk100m_b n11__clk100m_b 9.8382
rk91 n5__clk100m_b n12__clk100m_b 4.7264
rk92 n5__i70__net5 n6__i70__net5 38.0428
rk96 n13__i70__net4 i70__net4 15.5
rk97 n7__net3 n31__net3 45.3153
rk98 n31__net3 n32__net3 37.738
rk99 n31__net3 n33__net3 15.8221
rk100 n11__net15 n12__net15 529.7e-3
rk101 n12__net15 n13__net15 37.6786
rk102 n12__net15 n14__net15 15.7821
rk103 net3 n34__net3 500e-3
rk104 n13__net23 n14__net23 538.5e-3
rk105 n14__net23 n15__net23 37.6818
rk106 n14__net23 n16__net23 15.7788
rk107 n5__net17 n9__net17 45.0611
rk108 n51__clk100m n52__clk100m 4.733
rk109 n52__clk100m n53__clk100m 263.3e-3
rk110 n53__clk100m n54__clk100m 282.8e-3
rk111 n54__clk100m n55__clk100m 282.8e-3
rk112 n55__clk100m clk100m 222.2e-3
rk113 clk100m n1__clk100m 45.1116
rk114 n52__clk100m n56__clk100m 9.8448
rk115 n53__clk100m n57__clk100m 9.8382
rk116 n53__clk100m n58__clk100m 4.7264
rk117 n54__clk100m n59__clk100m 9.8382
rk118 n54__clk100m n60__clk100m 4.7264
rk119 n55__clk100m n61__clk100m 9.8382
rk120 n55__clk100m n62__clk100m 4.7264
rk121 i71__net3 n2__i71__net3 38.0375
rk123 n2__i71__net2 n4__i71__net2 42.9e-3
rk124 n3__i71__net2 n4__i71__net2 15.5
rk126 n6__i71__net2 n8__i71__net2 28.6e-3
rk127 n7__i71__net2 n8__i71__net2 15.5
rk128 n3__i71__net3 n4__i71__net3 38.0409
rk129 n5__net23 n17__net23 676.7e-3
rk130 n22__net3 n36__net3 675e-3
rk131 net23 n18__net23 500e-3
rk132 n5__i71__net3 n6__i71__net3 38.057
rk134 i71__net2 n12__i71__net2 42.9e-3
rk135 n11__i71__net2 n12__i71__net2 15.5
rk136 n51__net14 n52__net14 4.733
rk137 n52__net14 n53__net14 263.3e-3
rk138 n53__net14 net14 45.3338
rk139 n52__net14 n54__net14 9.8452
rk140 n53__net14 n55__net14 9.8382
rk141 n53__net14 n56__net14 4.7264
rk142 n5__i71__x n9__i71__x 45.3061
rk143 n9__i71__x n10__i71__x 37.738
rk144 n9__i71__x n11__i71__x 15.8221
rk148 n3__i71__net4 n2__i71__net4 15.5
rk149 i71__net5 n2__i71__net5 38.039
rk150 n24__net10 n25__net10 8.223
rk151 n25__net10 net10 311e-3
rk152 n25__net10 n26__net10 19.0225
rk156 n8__i71__net4 n7__i71__net4 15.5
rk157 n3__i71__net5 n4__i71__net5 38.0409
rk158 n26__net3 n37__net3 176.7e-3
rk159 n11__net23 n19__net23 175e-3
rk160 n29__net3 n38__net3 500e-3
rk161 n5__i71__net5 n6__i71__net5 38.0428
rk165 n13__i71__net4 i71__net4 15.5
rk166 n10__net4 n11__net4 15.7797
rk167 n11__net4 net4 293e-3
rk168 n11__net4 n12__net4 37.6762
rk169 n7__net12 n31__net12 45.3153
rk170 n31__net12 n32__net12 37.738
rk171 n31__net12 n33__net12 15.8221
rk172 n11__net17 n12__net17 529.7e-3
rk173 n12__net17 n13__net17 37.6786
rk174 n12__net17 n14__net17 15.7821
rk175 net2 n10__net2 500e-3
rk176 net12 n34__net12 500e-3
rk177 n11__net2 n12__net2 8.573
rk178 n13__net2 n14__net2 19.379
rk179 n2__i50__net1 n7__i50__net1 45.5
rk180 n13__net26 n14__net26 538.5e-3
rk181 n14__net26 n15__net26 37.6818
rk182 n14__net26 n16__net26 15.7788
rk183 n15__net7 n16__net7 8.2579
rk184 n16__net7 n18__net7 281.5e-3
rk185 n16__net7 n19__net7 247e-3
rk186 n19__net7 n20__net7 19.0041
rk187 n18__net7 n21__net7 28.6e-3
rk189 n19__net7 n23__net7 8.2058
rk190 n17__net7 n18__net7 18.75
rk191 n15__net2 n16__net2 8.573
rk192 n17__net2 n18__net2 19.379
rk193 n5__net19 n9__net19 45.5611
rk194 n5__i50__net1 n8__i50__net1 45.5
rk195 i72__net3 n2__i72__net3 38.0375
rk197 n2__i72__net2 n4__i72__net2 42.9e-3
rk198 n3__i72__net2 n4__i72__net2 15.5
rk200 n6__i72__net2 n8__i72__net2 28.6e-3
rk201 n7__i72__net2 n8__i72__net2 15.5
rk202 n3__i72__net3 n4__i72__net3 38.0409
rk203 i50__net2 n2__i50__net2 8.2547
rk204 n2__i50__net2 n3__i50__net2 273e-3
rk205 n3__i50__net2 n4__i50__net2 266.5e-3
rk206 n4__i50__net2 n5__i50__net2 19.0315
rk207 n2__i50__net2 n6__i50__net2 19.0268
rk208 n3__i50__net2 n7__i50__net2 19.0192
rk209 n3__i50__net2 n8__i50__net2 8.2423
rk210 n4__i50__net2 n9__i50__net2 8.2579
rk211 n5__net26 n17__net26 676.7e-3
rk212 n22__net12 n36__net12 675e-3
rk214 n5__i72__net3 n6__i72__net3 38.057
rk216 i72__net2 n12__i72__net2 42.9e-3
rk217 n11__i72__net2 n12__i72__net2 15.5
rk218 n25__net7 n24__net7 662.5e-3
rk219 n24__net7 n2__net7 45
rk220 n9__i50__net1 n11__i50__net1 823e-3
rk221 n11__i50__net1 n13__i50__net1 771.3e-3
rk222 n13__i50__net1 n14__i50__net1 629e-3
rk223 n10__i50__net1 n11__i50__net1 7.75
rk224 n12__i50__net1 n13__i50__net1 18.75
rk225 n5__i72__x n9__i72__x 45.3061
rk226 n9__i72__x n10__i72__x 37.738
rk227 n9__i72__x n11__i72__x 15.8221
rk231 n3__i72__net4 n2__i72__net4 15.5
rk232 i72__net5 n2__i72__net5 38.039
rk236 n3__i53__net4 n2__i53__net4 15.5
rk237 i53__net5 n2__i53__net5 38.0409
rk238 n18__clk1pt6g_b n42__clk1pt6g_b 500e-3
rk242 n8__i72__net4 n7__i72__net4 15.5
rk243 n3__i72__net5 n4__i72__net5 38.0409
rk244 n28__net12 n37__net12 176.7e-3
rk245 n11__net26 n19__net26 175e-3
rk246 n17__net8 n18__net8 15.8088
rk247 n18__net8 n12__net8 45.3165
rk248 n18__net8 n19__net8 37.7509
rk249 n24__net12 n38__net12 500e-3
rk250 n3__i53__net5 n4__i53__net5 38.0409
rk254 n8__i53__net4 n7__i53__net4 15.5
rk255 n5__i72__net5 n6__i72__net5 38.0428
rk259 n13__i72__net4 i72__net4 15.5
rk260 n24__clk1pt6g_b n45__clk1pt6g_b 676.7e-3
rk261 n18__clk1pt6g n42__clk1pt6g 675e-3
rk262 n7__net13 n31__net13 45.3153
rk263 n31__net13 n32__net13 37.738
rk264 n31__net13 n33__net13 15.8221
rk268 n13__i53__net4 i53__net4 15.5
rk269 n5__i53__net5 n6__i53__net5 38.039
rk270 n11__net19 n12__net19 529.7e-3
rk271 n12__net19 n13__net19 37.6786
rk272 n12__net19 n14__net19 15.7821
rk273 net13 n34__net13 500e-3
rk275 n2__i53__net2 n4__i53__net2 28.6e-3
rk276 n3__i53__net2 n4__i53__net2 15.5
rk277 i53__net3 n2__i53__net3 38.057
rk278 n23__clk1pt6g n43__clk1pt6g 500e-3
rk279 n9__i53__x n10__i53__x 15.8221
rk280 n10__i53__x i53__x 45.3061
rk281 n10__i53__x n11__i53__x 37.738
rk282 n3__i53__net3 n4__i53__net3 38.0409
rk284 n6__i53__net2 n8__i53__net2 28.6e-3
rk285 n7__i53__net2 n8__i53__net2 15.5
rk286 n13__net11 n14__net11 538.5e-3
rk287 n14__net11 n15__net11 37.6818
rk288 n14__net11 n16__net11 15.7788
rk289 n29__clk1pt6g n44__clk1pt6g 676.7e-3
rk290 n25__clk1pt6g_b n46__clk1pt6g_b 675e-3
rk292 i53__net2 n12__i53__net2 28.6e-3
rk293 n11__i53__net2 n12__i53__net2 15.5
rk294 n5__i53__net3 n6__i53__net3 38.0375
rk295 n5__net5 n9__net5 45.5611
rk296 i51__net3 n2__i51__net3 38.0375
rk298 n2__i51__net2 n4__i51__net2 42.9e-3
rk299 n3__i51__net2 n4__i51__net2 15.5
rk303 n3__i52__net4 n2__i52__net4 15.5
rk304 i52__net5 n2__i52__net5 38.0409
rk305 n30__clk1pt6g_b n47__clk1pt6g_b 500e-3
rk306 n27__net7 n28__net7 15.8293
rk307 n28__net7 n29__net7 131.2e-3
rk308 n29__net7 n7__net7 45.1759
rk309 n28__net7 n30__net7 37.7322
rk311 n6__i51__net2 n8__i51__net2 28.6e-3
rk312 n7__i51__net2 n8__i51__net2 15.5
rk313 n3__i51__net3 n4__i51__net3 38.0409
rk314 n5__net11 n17__net11 676.7e-3
rk315 n22__net13 n35__net13 675e-3
rk316 net11 n18__net11 500e-3
rk317 n3__i52__net5 n4__i52__net5 38.0409
rk321 n8__i52__net4 n7__i52__net4 15.5
rk322 n36__clk1pt6g_b n48__clk1pt6g_b 676.7e-3
rk323 n30__clk1pt6g n45__clk1pt6g 675e-3
rk324 n5__i51__net3 n6__i51__net3 38.057
rk326 i51__net2 n12__i51__net2 42.9e-3
rk327 n11__i51__net2 n12__i51__net2 15.5
rk331 n13__i52__net4 i52__net4 15.5
rk332 n5__i52__net5 n6__i52__net5 38.039
rk333 n5__i51__x n9__i51__x 45.3061
rk334 n9__i51__x n10__i51__x 37.738
rk335 n9__i51__x n11__i51__x 15.8221
rk339 n3__i51__net4 n2__i51__net4 15.5
rk340 i51__net5 n2__i51__net5 38.039
rk342 n2__i52__net2 n4__i52__net2 28.6e-3
rk343 n3__i52__net2 n4__i52__net2 15.5
rk344 i52__net3 n2__i52__net3 38.057
rk345 n35__clk1pt6g n46__clk1pt6g 500e-3
rk346 n9__i52__x n10__i52__x 15.8221
rk347 n10__i52__x i52__x 45.3061
rk348 n10__i52__x n11__i52__x 37.738
rk352 n8__i51__net4 n7__i51__net4 15.5
rk353 n3__i51__net5 n4__i51__net5 38.0409
rk354 n28__net13 n36__net13 676.7e-3
rk355 n11__net11 n19__net11 675e-3
rk356 n24__net13 n37__net13 500e-3
rk357 n3__i52__net3 n4__i52__net3 38.0409
rk359 n6__i52__net2 n8__i52__net2 28.6e-3
rk360 n7__i52__net2 n8__i52__net2 15.5
rk361 n41__clk1pt6g n47__clk1pt6g 676.7e-3
rk362 n37__clk1pt6g_b n49__clk1pt6g_b 675e-3
rk363 n5__i51__net5 n6__i51__net5 38.0428
rk367 n13__i51__net4 i51__net4 15.5
rk369 i52__net2 n12__i52__net2 28.6e-3
rk370 n11__i52__net2 n12__i52__net2 15.5
rk371 n5__i52__net3 n6__i52__net3 38.0375
rk372 n13__net6 n18__net6 45.3153
rk373 n18__net6 n19__net6 37.738
rk374 n18__net6 n20__net6 15.8221
rk375 n10__net5 n11__net5 529.7e-3
rk376 n11__net5 n12__net5 37.6786
rk377 n11__net5 n13__net5 15.7821
rk378 n1__vdd n2__vdd 15.78
rk379 n2__vdd n3__vdd 290.5e-3
rk380 n3__vdd n4__vdd 570.8e-3
rk381 n4__vdd n5__vdd 290.5e-3
rk382 n5__vdd n6__vdd 581.8e-3
rk383 n6__vdd n7__vdd 290.5e-3
rk384 n7__vdd n8__vdd 570.8e-3
rk385 n8__vdd n9__vdd 290.5e-3
rk386 n9__vdd n10__vdd 564.2e-3
rk387 n10__vdd n11__vdd 566.5e-3
rk388 n11__vdd n12__vdd 163.3e-3
rk389 n12__vdd n13__vdd 8.4801
rk390 n2__vdd n14__vdd 435.1e-3
rk391 n14__vdd n15__vdd 75.0024
rk392 n3__vdd n16__vdd 15.7982
rk393 n4__vdd n17__vdd 15.7982
rk394 n5__vdd n18__vdd 15.7982
rk395 n6__vdd n19__vdd 15.7982
rk396 n7__vdd n20__vdd 15.7982
rk397 n8__vdd n21__vdd 15.7982
rk398 n9__vdd n22__vdd 15.7982
rk399 n10__vdd n23__vdd 7.8913
rk400 n11__vdd n24__vdd 8.1851
rk401 n12__vdd n25__vdd 8.1851
rk402 n26__vdd n27__vdd 15.8547
rk403 n27__vdd n28__vdd 73.49e-3
rk404 n28__vdd n29__vdd 777.7e-3
rk405 n29__vdd n30__vdd 290.5e-3
rk406 n30__vdd n31__vdd 588.7e-3
rk407 n31__vdd n32__vdd 290.5e-3
rk408 n32__vdd n33__vdd 327.9e-3
rk409 n33__vdd n34__vdd 499.7e-3
rk410 n34__vdd n35__vdd 788.5e-3
rk411 n35__vdd n36__vdd 290.5e-3
rk412 n36__vdd n37__vdd 592.5e-3
rk413 n37__vdd n38__vdd 312.4e-3
rk414 n38__vdd n39__vdd 353.8e-3
rk415 n39__vdd n40__vdd 527.1e-3
rk416 n40__vdd n41__vdd 787.9e-3
rk417 n41__vdd n42__vdd 290.5e-3
rk418 n42__vdd n43__vdd 588.7e-3
rk419 n43__vdd n44__vdd 290.5e-3
rk420 n44__vdd n45__vdd 324.6e-3
rk421 n45__vdd n46__vdd 500.4e-3
rk422 n46__vdd n47__vdd 787.8e-3
rk423 n47__vdd n48__vdd 290.5e-3
rk424 n48__vdd n49__vdd 588.7e-3
rk425 n49__vdd n50__vdd 290.5e-3
rk426 n50__vdd n51__vdd 166.5e-3
rk427 n51__vdd n52__vdd 179.1e-3
rk428 n52__vdd n53__vdd 500.4e-3
rk429 n53__vdd n54__vdd 763.3e-3
rk430 n54__vdd n55__vdd 290.5e-3
rk431 n55__vdd n56__vdd 564.2e-3
rk432 n56__vdd n57__vdd 290.5e-3
rk433 n57__vdd n58__vdd 75.4378
rk434 n27__vdd n59__vdd 15.9447
rk435 n28__vdd n60__vdd 620.2e-3
rk436 n29__vdd n61__vdd 15.7982
rk437 n30__vdd n62__vdd 15.7982
rk438 n31__vdd n63__vdd 15.7982
rk439 n32__vdd n64__vdd 15.7766
rk440 n33__vdd n65__vdd 72.35e-3
rk441 n65__vdd n66__vdd 15.974
rk442 n34__vdd n67__vdd 72.35e-3
rk443 n67__vdd n68__vdd 15.9447
rk444 n35__vdd n69__vdd 15.7982
rk445 n36__vdd n70__vdd 15.7982
rk446 n37__vdd n71__vdd 15.7982
rk447 n38__vdd n72__vdd 15.7766
rk448 n39__vdd n73__vdd 72.35e-3
rk449 n73__vdd n74__vdd 15.974
rk450 n40__vdd n75__vdd 72.35e-3
rk451 n75__vdd n76__vdd 15.9447
rk452 n41__vdd n77__vdd 15.7982
rk453 n42__vdd n78__vdd 15.7982
rk454 n43__vdd n79__vdd 15.7982
rk455 n44__vdd n80__vdd 15.7766
rk456 n45__vdd n81__vdd 72.35e-3
rk457 n81__vdd n82__vdd 15.974
rk458 n46__vdd n83__vdd 72.35e-3
rk459 n83__vdd n84__vdd 15.9447
rk460 n47__vdd n85__vdd 15.7982
rk461 n48__vdd n86__vdd 15.7982
rk462 n49__vdd n87__vdd 15.7982
rk463 n50__vdd n88__vdd 15.7766
rk464 n51__vdd vdd 2.5451
rk465 vdd n89__vdd 374.7e-3
rk466 n89__vdd n90__vdd 297.9e-3
rk467 n90__vdd n92__vdd 15.12e-3
rk469 n52__vdd n94__vdd 72.35e-3
rk470 n94__vdd n95__vdd 15.974
rk471 n53__vdd n96__vdd 72.35e-3
rk472 n96__vdd n97__vdd 15.9447
rk473 n54__vdd n98__vdd 15.7982
rk474 n55__vdd n99__vdd 15.7982
rk475 n56__vdd n100__vdd 15.7982
rk476 n57__vdd n101__vdd 15.7766
rk477 n65__vdd n102__vdd 15.8296
rk478 n67__vdd n103__vdd 15.8806
rk479 n73__vdd n104__vdd 15.8296
rk480 n75__vdd n105__vdd 15.8806
rk481 n81__vdd n106__vdd 15.8296
rk482 n83__vdd n107__vdd 15.8806
rk483 n89__vdd n108__vdd 295.9e-3
rk484 n108__vdd n109__vdd 4.694
rk485 n94__vdd n110__vdd 15.8296
rk486 n96__vdd n111__vdd 15.8806
rk487 n108__vdd n112__vdd 295.9e-3
rk488 n112__vdd n113__vdd 4.694
rk489 n112__vdd n114__vdd 295.9e-3
rk490 n114__vdd n115__vdd 4.694
rk491 n114__vdd n116__vdd 295.9e-3
rk492 n116__vdd n117__vdd 4.6983
rk493 n116__vdd n118__vdd 163.3e-3
rk494 n118__vdd n119__vdd 4.6983
rk495 n118__vdd n120__vdd 295.9e-3
rk496 n120__vdd n121__vdd 4.694
rk497 n120__vdd n122__vdd 295.9e-3
rk498 n122__vdd n123__vdd 4.694
rk499 n122__vdd n124__vdd 295.9e-3
rk500 n124__vdd n125__vdd 4.694
rk501 n124__vdd n126__vdd 295.9e-3
rk502 n126__vdd n127__vdd 4.6983
rk503 n126__vdd n128__vdd 163.3e-3
rk504 n128__vdd n129__vdd 4.6983
rk505 n128__vdd n130__vdd 295.9e-3
rk506 n130__vdd n131__vdd 4.694
rk507 n130__vdd n132__vdd 295.9e-3
rk508 n132__vdd n133__vdd 4.652
rk509 n132__vdd n134__vdd 823.4e-3
rk510 n134__vdd n135__vdd 8.1689
rk511 n134__vdd n136__vdd 267.8e-3
rk512 n136__vdd n137__vdd 8.1851
rk513 n136__vdd n138__vdd 504.3e-3
rk514 n138__vdd n139__vdd 15.7671
rk515 n138__vdd n140__vdd 15.9884
rk516 n15__vdd n90__vdd 6.8182
rk517 n91__vdd n92__vdd 3.875
rk518 n9__net6 n21__net6 500e-3
rk519 net6 n22__net6 45.874
rk520 n1__vss n2__vss 62.1526
rk521 n2__vss n3__vss 2.0002
rk522 n3__vss n4__vss 757e-3
rk523 n4__vss n5__vss 295.9e-3
rk524 n5__vss n6__vss 568e-3
rk525 n6__vss n7__vss 296.2e-3
rk526 n7__vss n8__vss 327.9e-3
rk527 n8__vss n9__vss 483.1e-3
rk528 n9__vss n10__vss 757e-3
rk529 n10__vss n11__vss 295.9e-3
rk530 n11__vss n12__vss 568e-3
rk531 n12__vss n13__vss 296.2e-3
rk532 n13__vss n14__vss 327.9e-3
rk533 n14__vss n15__vss 483.1e-3
rk534 n15__vss n16__vss 757e-3
rk535 n16__vss n17__vss 295.9e-3
rk536 n17__vss n18__vss 568e-3
rk537 n18__vss n19__vss 296.2e-3
rk538 n19__vss n20__vss 324.6e-3
rk539 n20__vss n21__vss 483.1e-3
rk540 n21__vss n22__vss 757e-3
rk541 n22__vss n23__vss 295.9e-3
rk542 n23__vss n24__vss 568e-3
rk543 n24__vss n25__vss 296.2e-3
rk544 n25__vss n26__vss 324.6e-3
rk545 n26__vss n27__vss 483.1e-3
rk546 n27__vss n28__vss 757e-3
rk547 n28__vss n29__vss 295.9e-3
rk548 n29__vss n30__vss 568e-3
rk549 n30__vss n31__vss 296.2e-3
rk550 n31__vss vss 146.3e-3
rk551 vss n1__vss 62.2074
rk552 n2__vss n32__vss 195.6e-3
rk553 n32__vss n33__vss 296.2e-3
rk554 n33__vss n34__vss 568e-3
rk555 n34__vss n35__vss 295.9e-3
rk556 n35__vss n36__vss 580.9e-3
rk557 n36__vss n37__vss 296.2e-3
rk558 n37__vss n38__vss 568e-3
rk559 n38__vss n39__vss 269.8e-3
rk560 n39__vss n40__vss 631.2e-3
rk561 n40__vss n41__vss 299.1e-3
rk562 n41__vss n42__vss 163.3e-3
rk563 n42__vss n43__vss 290.4e-3
rk564 n43__vss n44__vss 1.5007
rk565 n44__vss n45__vss 441.1e-3
rk566 n45__vss n46__vss 303.4e-3
rk567 n46__vss n47__vss 295.9e-3
rk568 n47__vss n48__vss 313.2e-3
rk569 n48__vss n49__vss 163.3e-3
rk570 n49__vss n50__vss 295.9e-3
rk571 n50__vss n51__vss 295.9e-3
rk572 n51__vss n52__vss 295.9e-3
rk573 n52__vss n53__vss 316.5e-3
rk574 n53__vss n54__vss 163.3e-3
rk575 n54__vss n55__vss 302.3e-3
rk576 n55__vss n56__vss 303.1e-3
rk577 n56__vss n57__vss 295.9e-3
rk578 n57__vss n58__vss 509.4e-3
rk579 n58__vss n59__vss 9.3815
rk580 n3__vss n60__vss 62.64e-3
rk581 n60__vss n61__vss 37.8477
rk582 n4__vss n62__vss 37.6785
rk583 n5__vss n63__vss 37.6785
rk584 n6__vss n64__vss 37.6785
rk585 n7__vss n65__vss 37.6677
rk586 n8__vss n66__vss 62.64e-3
rk587 n66__vss n67__vss 37.8769
rk588 n9__vss n68__vss 62.64e-3
rk589 n68__vss n69__vss 37.8477
rk590 n10__vss n70__vss 37.6785
rk591 n11__vss n71__vss 37.6785
rk592 n12__vss n72__vss 37.6785
rk593 n13__vss n73__vss 37.6677
rk594 n14__vss n74__vss 62.64e-3
rk595 n74__vss n75__vss 37.8769
rk596 n15__vss n76__vss 62.64e-3
rk597 n76__vss n77__vss 37.8477
rk598 n16__vss n78__vss 37.6785
rk599 n17__vss n79__vss 37.6785
rk600 n18__vss n80__vss 37.6785
rk601 n19__vss n81__vss 37.6677
rk602 n20__vss n82__vss 62.64e-3
rk603 n82__vss n83__vss 37.8769
rk604 n21__vss n84__vss 62.64e-3
rk605 n84__vss n85__vss 37.8477
rk606 n22__vss n86__vss 37.6785
rk607 n23__vss n87__vss 37.6785
rk608 n24__vss n88__vss 37.6785
rk609 n25__vss n89__vss 37.6677
rk610 n26__vss n90__vss 62.64e-3
rk611 n90__vss n91__vss 37.8769
rk612 n27__vss n92__vss 62.64e-3
rk613 n92__vss n93__vss 37.8477
rk614 n28__vss n94__vss 37.6785
rk615 n29__vss n95__vss 37.6785
rk616 n30__vss n96__vss 37.6785
rk617 n31__vss n97__vss 37.6677
rk618 n32__vss n98__vss 37.6677
rk619 n33__vss n99__vss 37.6785
rk620 n34__vss n100__vss 37.6785
rk621 n35__vss n101__vss 37.6785
rk622 n36__vss n102__vss 37.6789
rk623 n37__vss n103__vss 37.6785
rk624 n38__vss n104__vss 37.6785
rk625 n39__vss n105__vss 37.7045
rk626 n40__vss n106__vss 18.975
rk627 n41__vss n107__vss 18.991
rk628 n42__vss n108__vss 18.991
rk629 n43__vss n109__vss 19.0128
rk630 n44__vss n110__vss 434.6e-3
rk631 n110__vss n111__vss 37.803
rk632 n45__vss n112__vss 279.4e-3
rk633 n112__vss n113__vss 19.1403
rk634 n46__vss n114__vss 9.7694
rk635 n47__vss n115__vss 9.8058
rk636 n48__vss n116__vss 9.8101
rk637 n49__vss n117__vss 9.8101
rk638 n50__vss n118__vss 9.8058
rk639 n51__vss n119__vss 9.8058
rk640 n52__vss n120__vss 9.8058
rk641 n53__vss n121__vss 9.8101
rk642 n54__vss n122__vss 9.8101
rk643 n55__vss n123__vss 9.8058
rk644 n56__vss n124__vss 9.8058
rk645 n57__vss n125__vss 9.8058
rk646 n60__vss n126__vss 37.7685
rk647 n66__vss n127__vss 37.7433
rk648 n68__vss n128__vss 37.7836
rk649 n74__vss n129__vss 37.7433
rk650 n76__vss n130__vss 37.7836
rk651 n82__vss n131__vss 37.7433
rk652 n84__vss n132__vss 37.7836
rk653 n90__vss n133__vss 37.7433
rk654 n92__vss n134__vss 37.7836
rk655 n110__vss n135__vss 37.7879
rk656 n112__vss n136__vss 19.135
rk657 n1__vss n58__vss 8.8571
rl1 net1 n2__net1 69.0385
rl2 n2__net1 n3__net1 70.9615
rl3 n3__net1 n4__net1 120.719
rl4 n4__net1 n5__net1 56.9251
rl5 n5__net1 n6__net1 56.9251
rl6 n6__net1 n7__net1 108.732
rl7 n5__net1 n8__net1 33.1687
rl8 n7__net1 net1 9.1667
rl9 n8__net1 n2__net1 27.9842
rl10 n1__clk1pt6g clk1pt6g 104.617
rl11 clk1pt6g n2__clk1pt6g 62.9487
rl12 n2__clk1pt6g n3__clk1pt6g 27.5641
rl13 n3__clk1pt6g n4__clk1pt6g 23.7402
rl14 n4__clk1pt6g n5__clk1pt6g 51.6011
rl15 n4__clk1pt6g n6__clk1pt6g 97.6734
rl16 n6__clk1pt6g n7__clk1pt6g 51.6131
rl17 n7__clk1pt6g n2__clk1pt6g 24.6956
rl18 n1__clk1pt6g_b n2__clk1pt6g_b 120.719
rl19 n2__clk1pt6g_b n3__clk1pt6g_b 25.7494
rl20 n3__clk1pt6g_b n4__clk1pt6g_b 51.4019
rl21 n3__clk1pt6g_b n5__clk1pt6g_b 88.6921
rl22 n5__clk1pt6g_b n1__clk1pt6g_b 9.1667
rl23 i69__x n2__i69__x 67.1154
rl24 n2__i69__x n3__i69__x 72.8846
rl25 n3__i69__x n4__i69__x 120.719
rl26 n4__i69__x n5__i69__x 60.7713
rl27 n5__i69__x n6__i69__x 53.079
rl28 n6__i69__x n7__i69__x 108.732
rl29 n5__i69__x n8__i69__x 33.1687
rl30 n7__i69__x i69__x 9.1667
rl31 n8__i69__x n2__i69__x 27.9842
rl32 n6__clk1pt6g_b clk1pt6g_b 104.617
rl33 clk1pt6g_b n7__clk1pt6g_b 62.9487
rl34 n7__clk1pt6g_b n8__clk1pt6g_b 27.5641
rl35 n8__clk1pt6g_b n9__clk1pt6g_b 23.7402
rl36 n9__clk1pt6g_b n10__clk1pt6g_b 51.6011
rl37 n9__clk1pt6g_b n11__clk1pt6g_b 97.6734
rl38 n11__clk1pt6g_b n12__clk1pt6g_b 51.6131
rl39 n12__clk1pt6g_b n7__clk1pt6g_b 24.6956
rl40 n8__clk1pt6g n9__clk1pt6g 109.826
rl41 n9__clk1pt6g n10__clk1pt6g 25.7494
rl42 n10__clk1pt6g n11__clk1pt6g 51.4019
rl43 n10__clk1pt6g n12__clk1pt6g 88.6921
rl44 n12__clk1pt6g n8__clk1pt6g 9.1667
rl45 net9 n2__net9 149.81
rl46 n2__net9 n3__net9 28.6538
rl47 n3__net9 n4__net9 40.0202
rl48 n4__net9 n5__net9 38.0971
rl49 n5__net9 n6__net9 120.719
rl50 n6__net9 n7__net9 28.079
rl51 n4__net9 n8__net9 156.963
rl52 n8__net9 n9__net9 38.0971
rl53 n9__net9 n10__net9 120.719
rl54 n10__net9 n11__net9 40.1923
rl55 n11__net9 n12__net9 27.9842
rl56 n7__net9 n13__net9 28.079
rl57 n13__net9 n14__net9 56.2572
rl58 n7__net9 n15__net9 34.6687
rl59 n11__net9 n16__net9 42.1154
rl60 n16__net9 n17__net9 120.719
rl61 n17__net9 n18__net9 15
rl62 n12__net9 n8__net9 32.0714
rl63 n14__net9 n2__net9 27.9842
rl64 n15__net9 n4__net9 32.0714
rl65 n18__net9 n8__net9 20.4048
rl66 net15 n2__net15 69.0385
rl67 n2__net15 n3__net15 70.9615
rl68 n3__net15 n4__net15 120.719
rl69 n4__net15 n5__net15 56.9251
rl70 n5__net15 n6__net15 56.9251
rl71 n6__net15 n7__net15 108.732
rl72 n5__net15 n8__net15 33.1687
rl73 n7__net15 net15 9.1667
rl74 n8__net15 n2__net15 27.9842
rl75 net20 n2__net20 125.643
rl76 n2__net20 n3__net20 27.5641
rl77 n3__net20 n4__net20 23.7402
rl78 n4__net20 n5__net20 51.6011
rl79 n4__net20 n6__net20 97.6734
rl80 n6__net20 n7__net20 51.6131
rl81 n7__net20 n2__net20 24.6956
rl82 n19__net9 n20__net9 120.719
rl83 n20__net9 n21__net9 25.7494
rl84 n21__net9 n22__net9 51.4019
rl85 n21__net9 n23__net9 88.6921
rl86 n23__net9 n19__net9 9.1667
rl87 i70__x n2__i70__x 67.1154
rl88 n2__i70__x n3__i70__x 72.8846
rl89 n3__i70__x n4__i70__x 120.719
rl90 n4__i70__x n5__i70__x 60.7713
rl91 n5__i70__x n6__i70__x 53.079
rl92 n6__i70__x n7__i70__x 108.732
rl93 n5__i70__x n8__i70__x 33.1687
rl94 n7__i70__x i70__x 9.1667
rl95 n8__i70__x n2__i70__x 27.9842
rl96 n24__net9 n25__net9 125.643
rl97 n25__net9 n26__net9 27.5641
rl98 n26__net9 n27__net9 23.7402
rl99 n27__net9 n28__net9 51.6011
rl100 n27__net9 n29__net9 97.6734
rl101 n29__net9 n30__net9 51.6131
rl102 n30__net9 n25__net9 24.6956
rl103 n8__net20 n9__net20 109.826
rl104 n9__net20 n10__net20 25.7494
rl105 n10__net20 n11__net20 51.4019
rl106 n10__net20 n12__net20 88.6921
rl107 n12__net20 n8__net20 9.1667
rl108 n1__clk100m n2__clk100m 28.079
rl109 n2__clk100m n3__clk100m 98.629
rl110 n3__clk100m n4__clk100m 76.5385
rl111 n4__clk100m n5__clk100m 76.5385
rl112 n5__clk100m n6__clk100m 76.5385
rl113 n6__clk100m n7__clk100m 76.5385
rl114 n7__clk100m n8__clk100m 76.5385
rl115 n8__clk100m n9__clk100m 98.629
rl116 n9__clk100m n10__clk100m 40.1923
rl117 n10__clk100m n11__clk100m 42.1154
rl118 n11__clk100m n12__clk100m 98.0548
rl119 n12__clk100m n13__clk100m 22.7584
rl120 n13__clk100m n14__clk100m 40.0202
rl121 n14__clk100m n15__clk100m 38.0971
rl122 n15__clk100m n16__clk100m 9.1667
rl123 n14__clk100m n17__clk100m 32.0714
rl124 n14__clk100m n18__clk100m 72.348
rl125 n18__clk100m n19__clk100m 38.0971
rl126 n19__clk100m n20__clk100m 9.1667
rl127 n16__clk100m n8__clk100m 10.4842
rl128 n17__clk100m n10__clk100m 27.9842
rl129 n18__clk100m n21__clk100m 40.0202
rl130 n21__clk100m n22__clk100m 22.7584
rl131 n22__clk100m n23__clk100m 33.5925
rl132 n20__clk100m n7__clk100m 10.4842
rl133 n22__clk100m n24__clk100m 75.3901
rl134 n24__clk100m n25__clk100m 22.7584
rl135 n25__clk100m n26__clk100m 40.0202
rl136 n26__clk100m n27__clk100m 38.0971
rl137 n27__clk100m n28__clk100m 9.1667
rl138 n23__clk100m n12__clk100m 33.5925
rl139 n26__clk100m n29__clk100m 32.0714
rl140 n26__clk100m n30__clk100m 72.348
rl141 n30__clk100m n31__clk100m 38.0971
rl142 n31__clk100m n32__clk100m 9.1667
rl143 n28__clk100m n6__clk100m 10.4842
rl144 n29__clk100m n18__clk100m 32.0714
rl145 n30__clk100m n33__clk100m 40.0202
rl146 n33__clk100m n34__clk100m 22.7584
rl147 n34__clk100m n35__clk100m 33.5925
rl148 n32__clk100m n5__clk100m 10.4842
rl149 n34__clk100m n36__clk100m 75.3901
rl150 n36__clk100m n37__clk100m 22.7584
rl151 n37__clk100m n38__clk100m 40.0202
rl152 n38__clk100m n39__clk100m 38.0971
rl153 n39__clk100m n40__clk100m 9.1667
rl154 n35__clk100m n24__clk100m 33.5925
rl155 n38__clk100m n41__clk100m 32.0714
rl156 n38__clk100m n42__clk100m 72.348
rl157 n42__clk100m n43__clk100m 38.0971
rl158 n43__clk100m n44__clk100m 9.1667
rl159 n40__clk100m n4__clk100m 10.4842
rl160 n41__clk100m n30__clk100m 32.0714
rl161 n42__clk100m n45__clk100m 40.0202
rl162 n45__clk100m n46__clk100m 22.7584
rl163 n46__clk100m n47__clk100m 33.5925
rl164 n42__clk100m n48__clk100m 32.0714
rl165 n44__clk100m n3__clk100m 10.4842
rl166 n46__clk100m n49__clk100m 98.0548
rl167 n49__clk100m n50__clk100m 10
rl168 n47__clk100m n36__clk100m 33.5925
rl169 n48__clk100m n1__clk100m 34.6687
rl170 n50__clk100m n1__clk100m 15.0021
rl171 net3 n2__net3 149.81
rl172 n2__net3 n3__net3 28.6538
rl173 n3__net3 n4__net3 40.0202
rl174 n4__net3 n5__net3 38.0971
rl175 n5__net3 n6__net3 120.719
rl176 n6__net3 n7__net3 28.079
rl177 n4__net3 n8__net3 156.963
rl178 n8__net3 n9__net3 38.0971
rl179 n9__net3 n10__net3 120.719
rl180 n10__net3 n11__net3 40.1923
rl181 n11__net3 n12__net3 27.9842
rl182 n7__net3 n13__net3 28.079
rl183 n13__net3 n14__net3 56.2572
rl184 n7__net3 n15__net3 34.6687
rl185 n11__net3 n16__net3 42.1154
rl186 n16__net3 n17__net3 120.719
rl187 n17__net3 n18__net3 15
rl188 n12__net3 n8__net3 32.0714
rl189 n14__net3 n2__net3 27.9842
rl190 n15__net3 n4__net3 32.0714
rl191 n18__net3 n8__net3 20.4048
rl192 net17 n2__net17 69.0385
rl193 n2__net17 n3__net17 70.9615
rl194 n3__net17 n4__net17 120.719
rl195 n4__net17 n5__net17 56.9251
rl196 n5__net17 n6__net17 56.9251
rl197 n6__net17 n7__net17 108.732
rl198 n5__net17 n8__net17 33.1687
rl199 n7__net17 net17 9.1667
rl200 n8__net17 n2__net17 27.9842
rl201 net14 n2__net14 28.079
rl202 n2__net14 n3__net14 98.629
rl203 n3__net14 n4__net14 76.5385
rl204 n4__net14 n5__net14 76.5385
rl205 n5__net14 n6__net14 76.5385
rl206 n6__net14 n7__net14 76.5385
rl207 n7__net14 n8__net14 76.5385
rl208 n8__net14 n9__net14 98.629
rl209 n9__net14 n10__net14 40.1923
rl210 n10__net14 n11__net14 42.1154
rl211 n11__net14 n12__net14 98.0548
rl212 n12__net14 n13__net14 22.7584
rl213 n13__net14 n14__net14 40.0202
rl214 n14__net14 n15__net14 38.0971
rl215 n15__net14 n16__net14 9.1667
rl216 n14__net14 n17__net14 32.0714
rl217 n14__net14 n18__net14 72.348
rl218 n18__net14 n19__net14 38.0971
rl219 n19__net14 n20__net14 9.1667
rl220 n16__net14 n8__net14 10.4842
rl221 n17__net14 n10__net14 27.9842
rl222 n18__net14 n21__net14 40.0202
rl223 n21__net14 n22__net14 22.7584
rl224 n22__net14 n23__net14 33.5925
rl225 n20__net14 n7__net14 10.4842
rl226 n22__net14 n24__net14 75.3901
rl227 n24__net14 n25__net14 22.7584
rl228 n25__net14 n26__net14 40.0202
rl229 n26__net14 n27__net14 38.0971
rl230 n27__net14 n28__net14 9.1667
rl231 n23__net14 n12__net14 33.5925
rl232 n26__net14 n29__net14 32.0714
rl233 n26__net14 n30__net14 72.348
rl234 n30__net14 n31__net14 38.0971
rl235 n31__net14 n32__net14 9.1667
rl236 n28__net14 n6__net14 10.4842
rl237 n29__net14 n18__net14 32.0714
rl238 n30__net14 n33__net14 40.0202
rl239 n33__net14 n34__net14 22.7584
rl240 n34__net14 n35__net14 33.5925
rl241 n32__net14 n5__net14 10.4842
rl242 n34__net14 n36__net14 75.3901
rl243 n36__net14 n37__net14 22.7584
rl244 n37__net14 n38__net14 40.0202
rl245 n38__net14 n39__net14 38.0971
rl246 n39__net14 n40__net14 9.1667
rl247 n35__net14 n24__net14 33.5925
rl248 n38__net14 n41__net14 32.0714
rl249 n38__net14 n42__net14 72.348
rl250 n42__net14 n43__net14 38.0971
rl251 n43__net14 n44__net14 9.1667
rl252 n40__net14 n4__net14 10.4842
rl253 n41__net14 n30__net14 32.0714
rl254 n42__net14 n45__net14 40.0202
rl255 n45__net14 n46__net14 22.7584
rl256 n46__net14 n47__net14 33.5925
rl257 n42__net14 n48__net14 32.0714
rl258 n44__net14 n3__net14 10.4842
rl259 n46__net14 n49__net14 98.0548
rl260 n49__net14 n50__net14 10
rl261 n47__net14 n36__net14 33.5925
rl262 n48__net14 net14 34.6687
rl263 n50__net14 net14 15.0021
rl264 net23 n2__net23 125.643
rl265 n2__net23 n3__net23 27.5641
rl266 n3__net23 n4__net23 23.7402
rl267 n4__net23 n5__net23 51.6011
rl268 n4__net23 n6__net23 97.6734
rl269 n6__net23 n7__net23 51.6131
rl270 n7__net23 n2__net23 24.6956
rl271 n19__net3 n20__net3 120.719
rl272 n20__net3 n21__net3 25.7494
rl273 n21__net3 n22__net3 51.4019
rl274 n21__net3 n23__net3 88.6921
rl275 n23__net3 n19__net3 9.1667
rl276 net10 n2__net10 51.3851
rl277 n2__net10 n3__net10 35.3603
rl278 n3__net10 n4__net10 98.629
rl279 n4__net10 n5__net10 76.5385
rl280 n5__net10 n6__net10 98.629
rl281 n6__net10 n7__net10 40.1923
rl282 n7__net10 n8__net10 42.1154
rl283 n8__net10 n9__net10 98.0548
rl284 n9__net10 n10__net10 22.7584
rl285 n10__net10 n11__net10 40.0202
rl286 n11__net10 n12__net10 38.0971
rl287 n12__net10 n13__net10 9.1667
rl288 n11__net10 n14__net10 32.0714
rl289 n11__net10 n15__net10 72.348
rl290 n15__net10 n16__net10 38.0971
rl291 n16__net10 n17__net10 9.1667
rl292 n13__net10 n5__net10 10.4842
rl293 n14__net10 n7__net10 27.9842
rl294 n15__net10 n18__net10 40.0202
rl295 n18__net10 n19__net10 22.7584
rl296 n19__net10 n20__net10 33.5925
rl297 n15__net10 n21__net10 32.0714
rl298 n17__net10 n4__net10 10.4842
rl299 n19__net10 n22__net10 98.0548
rl300 n22__net10 n23__net10 10.8333
rl301 n20__net10 n9__net10 33.5925
rl302 n21__net10 n2__net10 32.9951
rl303 n23__net10 n2__net10 25.0398
rl304 i71__x n2__i71__x 67.1154
rl305 n2__i71__x n3__i71__x 72.8846
rl306 n3__i71__x n4__i71__x 120.719
rl307 n4__i71__x n5__i71__x 60.7713
rl308 n5__i71__x n6__i71__x 53.079
rl309 n6__i71__x n7__i71__x 108.732
rl310 n5__i71__x n8__i71__x 33.1687
rl311 n7__i71__x i71__x 9.1667
rl312 n8__i71__x n2__i71__x 27.9842
rl313 net4 n2__net4 53.7308
rl314 n2__net4 n3__net4 35.3603
rl315 n3__net4 n4__net4 120.719
rl316 n4__net4 n5__net4 40.1923
rl317 n5__net4 n6__net4 42.1154
rl318 n6__net4 n7__net4 120.719
rl319 n7__net4 n8__net4 10.8333
rl320 n5__net4 n9__net4 27.9842
rl321 n8__net4 n2__net4 25.0398
rl322 n9__net4 n2__net4 32.9951
rl323 n24__net3 n25__net3 97.2539
rl324 n25__net3 n26__net3 51.9794
rl325 n25__net3 n27__net3 24.2362
rl326 n27__net3 n28__net3 26.6591
rl327 n28__net3 n29__net3 124.968
rl328 n28__net3 n30__net3 70.9249
rl329 n30__net3 n24__net3 8.3333
rl330 n8__net23 n9__net23 109.826
rl331 n9__net23 n10__net23 25.7494
rl332 n10__net23 n11__net23 51.4019
rl333 n10__net23 n12__net23 88.6921
rl334 n12__net23 n8__net23 9.1667
rl335 net2 n2__net2 61.7095
rl336 n2__net2 n3__net2 35.3603
rl337 n3__net2 n4__net2 120.719
rl338 n4__net2 n5__net2 40.1923
rl339 n5__net2 n6__net2 42.1154
rl340 n6__net2 n7__net2 120.719
rl341 n7__net2 n8__net2 10.8333
rl342 n5__net2 n9__net2 27.9842
rl343 n8__net2 n2__net2 25.0398
rl344 n9__net2 n2__net2 32.9951
rl345 i50__net1 n2__i50__net1 37.2721
rl346 n2__i50__net1 n3__i50__net1 38.1353
rl347 net12 n2__net12 149.81
rl348 n2__net12 n3__net12 28.6538
rl349 n3__net12 n4__net12 40.0202
rl350 n4__net12 n5__net12 38.0971
rl351 n5__net12 n6__net12 120.719
rl352 n6__net12 n7__net12 28.079
rl353 n4__net12 n8__net12 156.963
rl354 n8__net12 n9__net12 38.0971
rl355 n9__net12 n10__net12 120.719
rl356 n10__net12 n11__net12 40.1923
rl357 n11__net12 n12__net12 27.9842
rl358 n7__net12 n13__net12 28.079
rl359 n13__net12 n14__net12 56.2572
rl360 n7__net12 n15__net12 34.6687
rl361 n11__net12 n16__net12 42.1154
rl362 n16__net12 n17__net12 120.719
rl363 n17__net12 n18__net12 15
rl364 n12__net12 n8__net12 32.0714
rl365 n14__net12 n2__net12 27.9842
rl366 n15__net12 n4__net12 32.0714
rl367 n18__net12 n8__net12 20.4048
rl368 n4__i50__net1 n5__i50__net1 37.2721
rl369 n5__i50__net1 n6__i50__net1 38.1353
rl370 net19 n2__net19 69.0385
rl371 n2__net19 n3__net19 70.9615
rl372 n3__net19 n4__net19 120.719
rl373 n4__net19 n5__net19 56.9251
rl374 n5__net19 n6__net19 56.9251
rl375 n6__net19 n7__net19 108.732
rl376 n5__net19 n8__net19 33.1687
rl377 n7__net19 net19 9.1667
rl378 n8__net19 n2__net19 27.9842
rl379 net7 n2__net7 35.5308
rl380 n2__net7 n3__net7 74.1496
rl381 n3__net7 n4__net7 39.6181
rl382 n2__net7 n5__net7 33.5649
rl383 n3__net7 n6__net7 58.8489
rl384 net26 n2__net26 125.643
rl385 n2__net26 n3__net26 27.5641
rl386 n3__net26 n4__net26 23.7402
rl387 n4__net26 n5__net26 51.6011
rl388 n4__net26 n6__net26 97.6734
rl389 n6__net26 n7__net26 51.6131
rl390 n7__net26 n2__net26 24.6956
rl391 n19__net12 n20__net12 120.719
rl392 n20__net12 n21__net12 25.7494
rl393 n21__net12 n22__net12 51.4019
rl394 n21__net12 n23__net12 88.6921
rl395 n23__net12 n19__net12 9.1667
rl396 net8 n2__net8 63.143
rl397 n2__net8 n3__net8 402.313
rl398 n3__net8 n4__net8 63.143
rl399 n4__net8 n5__net8 40.1923
rl400 n5__net8 n6__net8 59.4231
rl401 n6__net8 n7__net8 82.3738
rl402 n7__net8 n8__net8 644.621
rl403 n8__net8 n9__net8 157.67
rl404 n2__net8 n10__net8 138.439
rl405 n7__net8 n11__net8 157.67
rl406 n11__net8 n12__net8 45.3867
rl407 n12__net8 n13__net8 28.079
rl408 n13__net8 n14__net8 96.6418
rl409 n8__net8 n15__net8 82.3738
rl410 n12__net8 n16__net8 34.6687
rl411 n14__net8 n3__net8 33.5925
rl412 n16__net8 n5__net8 27.9842
rl413 i72__x n2__i72__x 67.1154
rl414 n2__i72__x n3__i72__x 72.8846
rl415 n3__i72__x n4__i72__x 120.719
rl416 n4__i72__x n5__i72__x 60.7713
rl417 n5__i72__x n6__i72__x 53.079
rl418 n6__i72__x n7__i72__x 108.732
rl419 n5__i72__x n8__i72__x 33.1687
rl420 n7__i72__x i72__x 9.1667
rl421 n8__i72__x n2__i72__x 27.9842
rl422 n24__net12 n25__net12 125.643
rl423 n25__net12 n26__net12 27.5641
rl424 n26__net12 n27__net12 23.7402
rl425 n27__net12 n28__net12 51.6011
rl426 n27__net12 n29__net12 97.6734
rl427 n29__net12 n30__net12 51.6131
rl428 n30__net12 n25__net12 24.6956
rl429 n8__net26 n9__net26 109.826
rl430 n9__net26 n10__net26 25.7494
rl431 n10__net26 n11__net26 51.4019
rl432 n10__net26 n12__net26 88.6921
rl433 n12__net26 n8__net26 9.1667
rl434 n18__clk1pt6g_b n19__clk1pt6g_b 153.313
rl435 n19__clk1pt6g_b n20__clk1pt6g_b 27.5641
rl436 n20__clk1pt6g_b n21__clk1pt6g_b 97.6734
rl437 n21__clk1pt6g_b n22__clk1pt6g_b 23.7402
rl438 n22__clk1pt6g_b n23__clk1pt6g_b 51.6131
rl439 n21__clk1pt6g_b n24__clk1pt6g_b 51.6011
rl440 n23__clk1pt6g_b n19__clk1pt6g_b 24.6956
rl441 n18__clk1pt6g n19__clk1pt6g 51.4019
rl442 n19__clk1pt6g n20__clk1pt6g 25.7494
rl443 n20__clk1pt6g n21__clk1pt6g 109.826
rl444 n21__clk1pt6g n22__clk1pt6g 56.2572
rl445 n22__clk1pt6g n19__clk1pt6g 36.217
rl446 i53__x n2__i53__x 60.7713
rl447 n2__i53__x n3__i53__x 120.719
rl448 n3__i53__x n4__i53__x 72.8846
rl449 n4__i53__x n5__i53__x 67.1154
rl450 n5__i53__x n6__i53__x 120.719
rl451 n6__i53__x n7__i53__x 20.8333
rl452 n4__i53__x n8__i53__x 27.9842
rl453 n7__i53__x i53__x 25.8354
rl454 n8__i53__x i53__x 33.1687
rl455 n23__clk1pt6g n24__clk1pt6g 153.313
rl456 n24__clk1pt6g n25__clk1pt6g 27.5641
rl457 n25__clk1pt6g n26__clk1pt6g 97.6734
rl458 n26__clk1pt6g n27__clk1pt6g 23.7402
rl459 n27__clk1pt6g n28__clk1pt6g 51.6131
rl460 n26__clk1pt6g n29__clk1pt6g 51.6011
rl461 n28__clk1pt6g n24__clk1pt6g 24.6956
rl462 n25__clk1pt6g_b n26__clk1pt6g_b 51.4019
rl463 n26__clk1pt6g_b n27__clk1pt6g_b 25.7494
rl464 n27__clk1pt6g_b n28__clk1pt6g_b 120.719
rl465 n28__clk1pt6g_b n29__clk1pt6g_b 56.2572
rl466 n29__clk1pt6g_b n26__clk1pt6g_b 36.217
rl467 net13 n2__net13 149.798
rl468 n2__net13 n3__net13 28.4119
rl469 n3__net13 n4__net13 40.0202
rl470 n4__net13 n5__net13 38.0971
rl471 n5__net13 n6__net13 120.719
rl472 n6__net13 n7__net13 28.079
rl473 n4__net13 n8__net13 156.963
rl474 n8__net13 n9__net13 38.0971
rl475 n9__net13 n10__net13 120.719
rl476 n10__net13 n11__net13 40.1923
rl477 n11__net13 n12__net13 27.9842
rl478 n7__net13 n13__net13 28.079
rl479 n13__net13 n14__net13 55.4239
rl480 n7__net13 n15__net13 34.6687
rl481 n11__net13 n16__net13 42.1154
rl482 n16__net13 n17__net13 120.719
rl483 n17__net13 n18__net13 15
rl484 n12__net13 n8__net13 32.0714
rl485 n14__net13 n2__net13 27.3325
rl486 n15__net13 n4__net13 32.0714
rl487 n18__net13 n8__net13 20.4048
rl488 n7__net7 n8__net7 56.9251
rl489 n8__net7 n9__net7 120.719
rl490 n9__net7 n10__net7 70.9615
rl491 n10__net7 n11__net7 69.0385
rl492 n11__net7 n12__net7 120.719
rl493 n12__net7 n13__net7 22.5
rl494 n10__net7 n14__net7 27.9842
rl495 n13__net7 n7__net7 27.5021
rl496 n14__net7 n7__net7 33.1687
rl497 net5 n2__net5 69.0385
rl498 n2__net5 n3__net5 70.9615
rl499 n3__net5 n4__net5 120.719
rl500 n4__net5 n5__net5 56.9251
rl501 n5__net5 n6__net5 56.9251
rl502 n6__net5 n7__net5 108.732
rl503 n5__net5 n8__net5 33.1687
rl504 n7__net5 net5 9.1667
rl505 n8__net5 n2__net5 27.9842
rl506 n30__clk1pt6g_b n31__clk1pt6g_b 155.198
rl507 n31__clk1pt6g_b n32__clk1pt6g_b 27.2953
rl508 n32__clk1pt6g_b n33__clk1pt6g_b 97.6734
rl509 n33__clk1pt6g_b n34__clk1pt6g_b 23.7402
rl510 n34__clk1pt6g_b n35__clk1pt6g_b 50.8631
rl511 n33__clk1pt6g_b n36__clk1pt6g_b 51.6011
rl512 n35__clk1pt6g_b n31__clk1pt6g_b 24.134
rl513 n30__clk1pt6g n31__clk1pt6g 51.4019
rl514 n31__clk1pt6g n32__clk1pt6g 25.7494
rl515 n32__clk1pt6g n33__clk1pt6g 109.826
rl516 n33__clk1pt6g n34__clk1pt6g 56.2572
rl517 n34__clk1pt6g n31__clk1pt6g 36.217
rl518 net11 n2__net11 125.643
rl519 n2__net11 n3__net11 27.5641
rl520 n3__net11 n4__net11 23.7402
rl521 n4__net11 n5__net11 51.6011
rl522 n4__net11 n6__net11 97.6734
rl523 n6__net11 n7__net11 51.6131
rl524 n7__net11 n2__net11 24.6956
rl525 n19__net13 n20__net13 120.719
rl526 n20__net13 n21__net13 25.7494
rl527 n21__net13 n22__net13 51.4019
rl528 n21__net13 n23__net13 88.6921
rl529 n23__net13 n19__net13 9.1667
rl530 i52__x n2__i52__x 60.7713
rl531 n2__i52__x n3__i52__x 120.719
rl532 n3__i52__x n4__i52__x 72.8846
rl533 n4__i52__x n5__i52__x 67.1154
rl534 n5__i52__x n6__i52__x 120.719
rl535 n6__i52__x n7__i52__x 20.8333
rl536 n4__i52__x n8__i52__x 27.9842
rl537 n7__i52__x i52__x 25.8354
rl538 n8__i52__x i52__x 33.1687
rl539 i51__x n2__i51__x 67.1154
rl540 n2__i51__x n3__i51__x 72.8846
rl541 n3__i51__x n4__i51__x 120.719
rl542 n4__i51__x n5__i51__x 60.7713
rl543 n5__i51__x n6__i51__x 53.079
rl544 n6__i51__x n7__i51__x 108.732
rl545 n5__i51__x n8__i51__x 33.1687
rl546 n7__i51__x i51__x 9.1667
rl547 n8__i51__x n2__i51__x 27.9842
rl548 n35__clk1pt6g n36__clk1pt6g 153.313
rl549 n36__clk1pt6g n37__clk1pt6g 27.5641
rl550 n37__clk1pt6g n38__clk1pt6g 97.6734
rl551 n38__clk1pt6g n39__clk1pt6g 23.7402
rl552 n39__clk1pt6g n40__clk1pt6g 51.6131
rl553 n38__clk1pt6g n41__clk1pt6g 51.6011
rl554 n40__clk1pt6g n36__clk1pt6g 24.6956
rl555 n37__clk1pt6g_b n38__clk1pt6g_b 51.4019
rl556 n38__clk1pt6g_b n39__clk1pt6g_b 25.7494
rl557 n39__clk1pt6g_b n40__clk1pt6g_b 120.719
rl558 n40__clk1pt6g_b n41__clk1pt6g_b 56.2572
rl559 n41__clk1pt6g_b n38__clk1pt6g_b 36.217
rl560 n24__net13 n25__net13 125.643
rl561 n25__net13 n26__net13 27.5641
rl562 n26__net13 n27__net13 23.7402
rl563 n27__net13 n28__net13 51.6011
rl564 n27__net13 n29__net13 97.6734
rl565 n29__net13 n30__net13 51.6131
rl566 n30__net13 n25__net13 24.6956
rl567 n8__net11 n9__net11 109.826
rl568 n9__net11 n10__net11 25.7494
rl569 n10__net11 n11__net11 51.4019
rl570 n10__net11 n12__net11 88.6921
rl571 n12__net11 n8__net11 9.1667
rl572 net6 n2__net6 56.9251
rl573 n2__net6 n3__net6 120.719
rl574 n3__net6 n4__net6 70.9615
rl575 n4__net6 n5__net6 69.0385
rl576 n5__net6 n6__net6 120.719
rl577 n6__net6 n7__net6 22.5
rl578 n4__net6 n8__net6 27.9842
rl579 n7__net6 net6 27.5021
rl580 n8__net6 net6 33.1687
rl581 n9__net6 n10__net6 155.407
rl582 n10__net6 n11__net6 38.0971
rl583 n11__net6 n12__net6 120.719
rl584 n12__net6 n13__net6 28.079
rl585 n13__net6 n14__net6 28.079
rl586 n14__net6 n15__net6 120.719
rl587 n15__net6 n16__net6 15
rl588 n13__net6 n17__net6 34.6687
rl589 n16__net6 n10__net6 20.4048
rl590 n17__net6 n10__net6 32.0714
mi58__pm0_7__rcx n12__clk100m_b n11__clk100m n91__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__pm0_6__rcx n109__vdd n13__clk100m n12__clk100m_b n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__pm0_5__rcx n10__clk100m_b n21__clk100m n109__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__pm0_4__rcx n113__vdd n25__clk100m n10__clk100m_b n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__pm0_3__rcx n8__clk100m_b n33__clk100m n113__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__pm0_2__rcx n115__vdd n37__clk100m n8__clk100m_b n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__pm0_1__rcx n1__clk100m_b n45__clk100m n115__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__pm0 n117__vdd n49__clk100m n1__clk100m_b n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=268.8e-15 AS=268.8e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi54__pm0_1__rcx n10__net4 n6__net2 n139__vdd n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi54__pm0 n140__vdd n7__net2 n10__net4 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi63__pm0_1__rcx n13__net5 n14__net6 n59__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi63__pm0 n26__vdd n15__net6 n13__net5 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi67__pm0_1__rcx n16__net11 n17__net13 n66__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi67__pm0 n102__vdd n16__net13 n16__net11 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi62__pm0_1__rcx n14__net19 n13__net13 n68__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi62__pm0 n103__vdd n3__net13 n14__net19 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi66__pm0_1__rcx n16__net26 n17__net12 n74__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi66__pm0 n104__vdd n16__net12 n16__net26 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi61__pm0_1__rcx n14__net17 n13__net12 n76__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi61__pm0 n105__vdd n3__net12 n14__net17 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi65__pm0_1__rcx n16__net23 n17__net3 n82__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi65__pm0 n106__vdd n16__net3 n16__net23 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi60__pm0_1__rcx n14__net15 n13__net3 n84__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi60__pm0 n107__vdd n3__net3 n14__net15 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi64__pm0_1__rcx n16__net20 n17__net9 n95__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi64__pm0 n110__vdd n16__net9 n16__net20 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi59__pm0_1__rcx n14__net1 n13__net9 n97__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi59__pm0 n111__vdd n3__net9 n14__net1 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm0_1__rcx n11__i53__net2 n12__net7 n19__vdd n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm0 n20__vdd n11__net7 n11__i53__net2 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm1_1__rcx n9__i53__x n27__clk1pt6g n7__i53__net2 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm1 n3__i53__net2 n25__clk1pt6g n9__i53__x n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm2_1__rcx n13__i53__net4 n6__i53__x n21__vdd n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm2 n22__vdd n5__i53__x n13__i53__net4 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm3_1__rcx n17__net8 n22__clk1pt6g_b n8__i53__net4 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi53__pm3 n3__i53__net4 n20__clk1pt6g_b n17__net8 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm0_1__rcx n3__i51__net2 n6__net5 n64__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm0 n63__vdd net5 n3__i51__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm1_1__rcx n11__i51__x n3__net11 n7__i51__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm1 n11__i51__net2 n6__net11 n11__i51__x n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm2_1__rcx n3__i51__net4 n6__i51__x n62__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm2 n61__vdd i51__x n3__i51__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm3_1__rcx n20__net6 n26__net13 n8__i51__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi51__pm3 n13__i51__net4 n29__net13 n20__net6 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm0_1__rcx n3__i72__net2 n6__net19 n72__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm0 n71__vdd net19 n3__i72__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm1_1__rcx n11__i72__x n3__net26 n7__i72__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm1 n11__i72__net2 n6__net26 n11__i72__x n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm2_1__rcx n3__i72__net4 n6__i72__x n70__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm2 n69__vdd i72__x n3__i72__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm3_1__rcx n33__net13 n26__net12 n8__i72__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi72__pm3 n13__i72__net4 n29__net12 n33__net13 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm0_1__rcx n3__i71__net2 n6__net17 n80__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm0 n79__vdd net17 n3__i71__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm1_1__rcx n11__i71__x n3__net23 n7__i71__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm1 n11__i71__net2 n6__net23 n11__i71__x n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm2_1__rcx n3__i71__net4 n6__i71__x n78__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm2 n77__vdd i71__x n3__i71__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm3_1__rcx n33__net12 n27__net3 n8__i71__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi71__pm3 n13__i71__net4 n24__net3 n33__net12 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm0_1__rcx n3__i70__net2 n6__net15 n88__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm0 n87__vdd net15 n3__i70__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm1_1__rcx n11__i70__x n3__net20 n7__i70__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm1 n11__i70__net2 n6__net20 n11__i70__x n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm2_1__rcx n3__i70__net4 n6__i70__x n86__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm2 n85__vdd i70__x n3__i70__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm3_1__rcx n33__net3 n26__net9 n8__i70__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi70__pm3 n13__i70__net4 n29__net9 n33__net3 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm0_1__rcx n11__i52__net2 n6__net6 n1__vdd n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm0 n16__vdd n5__net6 n11__i52__net2 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm1_1__rcx n9__i52__x n39__clk1pt6g n7__i52__net2 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm1 n3__i52__net2 n37__clk1pt6g n9__i52__x n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm2_1__rcx n13__i52__net4 n6__i52__x n17__vdd n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm2 n18__vdd n5__i52__x n13__i52__net4 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm3_1__rcx n27__net7 n34__clk1pt6g_b n8__i52__net4 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi52__pm3 n3__i52__net4 n32__clk1pt6g_b n27__net7 n15__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm0_1__rcx n3__i69__net2 n6__net1 n101__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm0 n100__vdd net1 n3__i69__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm1_1__rcx n11__i69__x n3__clk1pt6g n7__i69__net2 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm1 n11__i69__net2 n6__clk1pt6g n11__i69__x n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm2_1__rcx n3__i69__net4 n6__i69__x n99__vdd n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm2 n98__vdd i69__x n3__i69__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm3_1__rcx n33__net9 n8__clk1pt6g_b n8__i69__net4 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi69__pm3 n13__i69__net4 n11__clk1pt6g_b n33__net9 n58__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i9__pm0_1__rcx n24__vdd n6__net8 n10__i50__net1 n15__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i9__pm0 n10__i50__net1 n11__net8 n23__vdd n15__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i8__pm0_1__rcx n13__vdd n6__net7 i50__net2 n15__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i8__pm0 i50__net2 net7 n25__vdd n15__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i11__pm0_1__rcx n9__i50__net2 n6__i50__net1 n15__net2 n15__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i11__pm0 n15__net2 n4__i50__net1 n8__i50__net2 n15__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i10__pm0_1__rcx n23__net7 n9__net8 n11__net2 n15__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i10__pm0 n11__net2 n15__net8 n15__net7 n15__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__pm0_3__rcx n56__net14 n8__net10 n129__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__pm0_2__rcx n131__vdd n10__net10 n56__net14 n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__pm0_1__rcx n51__net14 n18__net10 n131__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__pm0 n133__vdd n22__net10 n51__net14 n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=268.8e-15 AS=268.8e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi55__pm0_1__rcx n24__net10 n6__net4 n135__vdd n15__vdd g45p1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi55__pm0 n137__vdd n7__net4 n24__net10 n15__vdd g45p1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0_7__rcx n62__clk100m n11__net14 n119__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0_6__rcx n121__vdd n13__net14 n62__clk100m n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0_5__rcx n60__clk100m n21__net14 n121__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0_4__rcx n123__vdd n25__net14 n60__clk100m n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0_3__rcx n58__clk100m n33__net14 n123__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0_2__rcx n125__vdd n37__net14 n58__clk100m n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0_1__rcx n51__clk100m n45__net14 n125__vdd n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=307.2e-15 AS=307.2e-15 PD=4.16e-6 PS=4.16e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__pm0 n127__vdd n49__net14 n51__clk100m n15__vdd g45p1svt L=45e-9 W=1.92e-6 AD=268.8e-15 AS=268.8e-15 PD=4.14e-6 PS=4.14e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0_7__rcx n11__clk100m_b n9__clk100m n59__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0_6__rcx n125__vss n15__clk100m n11__clk100m_b n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0_5__rcx n9__clk100m_b n19__clk100m n125__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0_4__rcx n124__vss n27__clk100m n9__clk100m_b n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0_3__rcx n7__clk100m_b n31__clk100m n124__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0_2__rcx n123__vss n39__clk100m n7__clk100m_b n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0_1__rcx n6__clk100m_b n43__clk100m n123__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi58__nm0 n122__vss n2__clk100m n6__clk100m_b n1__vss g45n1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi54__nm0_1__rcx n12__net4 n4__net2 n111__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi54__nm0 n135__vss n3__net2 n12__net4 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi63__nm0_1__rcx n12__net5 n12__net6 n61__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi63__nm0 n126__vss n11__net6 n12__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi67__nm0_1__rcx n15__net11 n9__net13 n67__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi67__nm0 n127__vss n10__net13 n15__net11 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi62__nm0_1__rcx n13__net19 n6__net13 n69__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi62__nm0 n128__vss n5__net13 n13__net19 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi66__nm0_1__rcx n15__net26 n9__net12 n75__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi66__nm0 n129__vss n10__net12 n15__net26 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi61__nm0_1__rcx n13__net17 n6__net12 n77__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi61__nm0 n130__vss n5__net12 n13__net17 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi65__nm0_1__rcx n15__net23 n9__net3 n83__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi65__nm0 n131__vss n10__net3 n15__net23 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi60__nm0_1__rcx n13__net15 n6__net3 n85__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi60__nm0 n132__vss n5__net3 n13__net15 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi64__nm0_1__rcx n15__net20 n9__net9 n91__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi64__nm0 n133__vss n10__net9 n15__net20 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi59__nm0_1__rcx n13__net1 n6__net9 n93__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi59__nm0 n134__vss n5__net9 n13__net1 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm1_1__rcx n5__i53__net3 n8__net7 n102__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm1 n103__vss n9__net7 n5__i53__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm0_1__rcx n11__i53__x n27__clk1pt6g_b n3__i53__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm0 i53__net3 n28__clk1pt6g_b n11__i53__x n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm3_1__rcx n5__i53__net5 n2__i53__x n104__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm3 n105__vss n3__i53__x n5__i53__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm2_1__rcx n19__net8 n20__clk1pt6g n3__i53__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi53__nm2 i53__net5 n21__clk1pt6g n19__net8 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm1_1__rcx i51__net3 n4__net5 n65__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm1 n64__vss n3__net5 i51__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm0_1__rcx n10__i51__x n20__net13 n3__i51__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm0 n5__i51__net3 n19__net13 n10__i51__x n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm3_1__rcx i51__net5 n4__i51__x n63__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm3 n62__vss n3__i51__x i51__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm2_1__rcx n19__net6 n9__net11 n3__i51__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi51__nm2 n5__i51__net5 n8__net11 n19__net6 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm1_1__rcx i72__net3 n4__net19 n73__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm1 n72__vss n3__net19 i72__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm0_1__rcx n10__i72__x n20__net12 n3__i72__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm0 n5__i72__net3 n19__net12 n10__i72__x n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm3_1__rcx i72__net5 n4__i72__x n71__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm3 n70__vss n3__i72__x i72__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm2_1__rcx n32__net13 n9__net26 n3__i72__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi72__nm2 n5__i72__net5 n8__net26 n32__net13 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm1_1__rcx i71__net3 n4__net17 n81__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm1 n80__vss n3__net17 i71__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm0_1__rcx n10__i71__x n20__net3 n3__i71__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm0 n5__i71__net3 n19__net3 n10__i71__x n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm3_1__rcx i71__net5 n4__i71__x n79__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm3 n78__vss n3__i71__x i71__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm2_1__rcx n32__net12 n9__net23 n3__i71__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi71__nm2 n5__i71__net5 n8__net23 n32__net12 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm1_1__rcx i70__net3 n4__net15 n89__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm1 n88__vss n3__net15 i70__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm0_1__rcx n10__i70__x n20__net9 n3__i70__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm0 n5__i70__net3 n19__net9 n10__i70__x n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm3_1__rcx i70__net5 n4__i70__x n87__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm3 n86__vss n3__i70__x i70__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm2_1__rcx n32__net3 n9__net20 n3__i70__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi70__nm2 n5__i70__net5 n8__net20 n32__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm1_1__rcx n5__i52__net3 n2__net6 n98__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm1 n99__vss n3__net6 n5__i52__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm0_1__rcx n11__i52__x n39__clk1pt6g_b n3__i52__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm0 i52__net3 n40__clk1pt6g_b n11__i52__x n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm3_1__rcx n5__i52__net5 n2__i52__x n100__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm3 n101__vss n3__i52__x n5__i52__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm2_1__rcx n30__net7 n32__clk1pt6g n3__i52__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi52__nm2 i52__net5 n33__clk1pt6g n30__net7 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm1_1__rcx i69__net3 n4__net1 n97__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm1 n96__vss n3__net1 i69__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm0_1__rcx n10__i69__x n2__clk1pt6g_b n3__i69__net3 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm0 n5__i69__net3 n1__clk1pt6g_b n10__i69__x n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm3_1__rcx i69__net5 n4__i69__x n95__vss n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm3 n94__vss n3__i69__x i69__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm2_1__rcx n32__net9 n9__clk1pt6g n3__i69__net5 n1__vss g45n1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi69__nm2 n5__i69__net5 n8__clk1pt6g n32__net9 n1__vss g45n1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0_7__rcx n120__vss n15__net14 n61__clk100m n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0_6__rcx n59__clk100m n19__net14 n120__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0_5__rcx n119__vss n27__net14 n59__clk100m n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0_4__rcx n57__clk100m n31__net14 n119__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0_3__rcx n118__vss n39__net14 n57__clk100m n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0_2__rcx n56__clk100m n43__net14 n118__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0_1__rcx n117__vss n2__net14 n56__clk100m n1__vss g45n1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi57__nm0 n61__clk100m n9__net14 n121__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi55__nm0_1__rcx n136__vss n3__net4 n26__net10 n1__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi55__nm0 n26__net10 n4__net4 n113__vss n1__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i9__nm0_1__rcx n107__vss n4__net8 n12__i50__net1 n1__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i9__nm0 n12__i50__net1 n13__net8 n106__vss n1__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i8__nm0_1__rcx n109__vss n4__net7 n6__i50__net2 n1__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i8__nm0 n6__i50__net2 n5__net7 n108__vss n1__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i11__nm0_1__rcx n5__i50__net2 n10__net8 n17__net2 n1__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i11__nm0 n17__net2 net8 n7__i50__net2 n1__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i10__nm0_1__rcx n20__net7 n3__i50__net1 n13__net2 n1__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi50__i10__nm0 n13__net2 i50__net1 n17__net7 n1__vss g45n1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__nm0_3__rcx n55__net14 n6__net10 n116__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__nm0_2__rcx n115__vss n12__net10 n55__net14 n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__nm0_1__rcx n54__net14 n16__net10 n115__vss n1__vss g45n1svt L=45e-9 W=960e-9 AD=153.6e-15 AS=153.6e-15 PD=2.24e-6 PS=2.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi56__nm0 n114__vss n3__net10 n54__net14 n1__vss g45n1svt L=45e-9 W=960e-9 AD=134.4e-15 AS=134.4e-15 PD=2.22e-6 PS=2.22e-6 NRD=1.16667 NRS=1.16667 M=1

vclk1pt6g clk1pt6g 0 pulse(0 1.1 400p 10p 10p 302.5p 625p)
vvVDD vdd 0 1.1
vGND vss 0 0
.tran 1p 256n
.measure tran avg_power avg p(vVDD) from=0n to=256n
.option post
.end
